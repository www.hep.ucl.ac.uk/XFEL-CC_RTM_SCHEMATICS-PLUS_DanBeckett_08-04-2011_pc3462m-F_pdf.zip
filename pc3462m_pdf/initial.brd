# Allegro board initial.brd (continued)
## Nets (continued)
GND: C1.1(A<0>) C2.1(A<0>) C3.1(A<0>) C4.2(B<0>) C5.1(A<0>) C6.1(A<0>) C7.1(A<0>) C8.1(A<0>) C9.1(A<0>) C10.1(A<0>) C11.1(A<0>) C12.1(A<0>) C13.1(A<0>) C14.1(A<0>) C15.1(A<0>) C16.1(A<0>) C17.1(A<0>) C18.1(A<0>) C19.1(A<0>) C20.1(A<0>) C21.1(A<0>) C24.1(A<0>) C25.1(A<0>) C26.1(A<0>) C27.1(A<0>) C28.1(A<0>) C29.1(A<0>) C30.1(A<0>) C31.1(A<0>) C32.1(A<0>) C33.1(A<0>) C34.1(A<0>) C35.1(A<0>) C40.1(A<0>) C41.1(A<0>) C42.1(A<0>) C43.1(A<0>) C44.1(A<0>) C45.1(A<0>) C46.1(A<0>) C47.1(A<0>) C48.1(A<0>) C49.1(A<0>) C50.1(A<0>) C51.1(A<0>) C52.1(A<0>) C53.1(A<0>) C54.1(A<0>) C55.1(A<0>) C56.1(A<0>) C57.1(A<0>) C58.1(A<0>) C61.1(A<0>) C62.1(A<0>) C63.1(A<0>) C64.1(A<0>) C65.1(A<0>) C66.1(A<0>) C67.1(A<0>) C68.1(A<0>) C69.1(A<0>) C70.1(A<0>) C75.1(A<0>) C76.1(A<0>) C77.1(A<0>) C78.1(A<0>) C79.1(A<0>) C80.1(A<0>) C81.1(A<0>) C83.1(A<0>) C84.1(A<0>) C85.1(A<0>) C86.1(A<0>) C87.1(A<0>) C88.1(A<0>) C89.1(A<0>) C90.1(A<0>) C91.1(A<0>) C92.1(A<0>) C93.1(A<0>) C94.1(A<0>) C95.1(A<0>) C96.1(A<0>) C97.1(A<0>) C98.1(A<0>) C99.1(A<0>) C100.1(A<0>) C101.1(A<0>) C106.1(A<0>) C107.1(A<0>) C108.1(A<0>) C109.1(A<0>) C110.1(A<0>) C111.1(A<0>) C112.1(A<0>) C113.1(A<0>) C114.1(A<0>) C115.1(A<0>) C120.1(A<0>) C121.1(A<0>) C122.1(A<0>) C123.1(A<0>) C124.1(A<0>) C125.1(A<0>) C126.1(A<0>) C127.1(A<0>) C128.1(A<0>) C129.1(A<0>) C134.1(A<0>) C135.1(A<0>) C136.1(A<0>) C137.1(A<0>) C138.1(A<0>) C139.1(A<0>) C140.1(A<0>) C141.1(A<0>) C142.1(A<0>) C143.1(A<0>) C148.1(A<0>) C149.1(A<0>) C150.1(A<0>) C151.1(A<0>) C152.1(A<0>) C153.1(A<0>) C154.1(A<0>) C155.1(A<0>) C156.1(A<0>) C157.1(A<0>) C162.1(A<0>) C163.1(A<0>) C164.1(A<0>) C165.1(A<0>) C166.1(A<0>) C167.1(A<0>) C168.1(A<0>) C169.1(A<0>) C170.1(A<0>) C171.1(A<0>) C176.1(A<0>) C177.1(A<0>) C178.1(A<0>) C179.1(A<0>) C180.1(A<0>) C181.1(A<0>) C182.1(A<0>) C183.1(A<0>) C184.1(A<0>) C185.1(A<0>) C186.1(A<0>) C187.1(A<0>) DS2.2(K1) DS3.2(K1) DS4.2(K1) LK5.1(A<0>) LK5.2(B<0>) LK6.1(A<0>) LK6.2(B<0>) LK7.1(A<0>) LK7.2(B<0>) LK8.1(A<0>) LK8.2(B<0>) LK9.1(A<0>) LK10.1(A<0>) PL1.1(A<0>) PL2.1(A<0>) PL3.1(A<0>) PL4.1(A<0>) PL5.1(A<0>) PL6.1(A<0>) PL7.1(A<0>) PL9.AB1(GND1) PL9.AB2(GND2) PL9.AB3(GND3) PL9.AB4(GND4) PL9.AB5(GND5) PL9.AB6(GND6) PL9.AB7(GND7) PL9.AB8(GND8) PL9.AB9(GND9) PL9.AB10(GND10) PL9.CD1(GND11) PL9.CD2(GND12) PL9.CD3(GND13) PL9.CD4(GND14) PL9.CD5(GND15) PL9.CD6(GND16) PL9.CD7(GND17) PL9.CD8(GND18) PL9.CD9(GND19) PL9.CD10(GND20) PL9.EF1(GND21) PL9.EF2(GND22) PL9.EF3(GND23) PL9.EF4(GND24) PL9.EF5(GND25) PL9.EF6(GND26) PL9.EF7(GND27) PL9.EF8(GND28) PL9.EF9(GND29) PL9.EF10(GND30) PL10.AB1(GND1) PL10.AB2(GND2) PL10.AB3(GND3) PL10.AB4(GND4) PL10.AB5(GND5) PL10.AB6(GND6) PL10.AB7(GND7) PL10.AB8(GND8) PL10.AB9(GND9) PL10.AB10(GND10) PL10.CD1(GND11) PL10.CD2(GND12) PL10.CD3(GND13) PL10.CD4(GND14) PL10.CD5(GND15) PL10.CD6(GND16) PL10.CD7(GND17) PL10.CD8(GND18) PL10.CD9(GND19) PL10.CD10(GND20) PL10.EF1(GND21) PL10.EF2(GND22) PL10.EF3(GND23) PL10.EF4(GND24) PL10.EF5(GND25) PL10.EF6(GND26) PL10.EF7(GND27) PL10.EF8(GND28) PL10.EF9(GND29) PL10.EF10(GND30) R1.1(A<0>) R2.1(A<0>) R7.1(A<0>) R9.1(A<0>) R11.1(A<0>) R13.1(A<0>) R15.1(A<0>) R17.1(A<0>) R19.1(A<0>) R28.1(A<0>) R69.1(A<0>) R71.1(A<0>) R73.1(A<0>) R75.1(A<0>) R77.1(A<0>) R79.1(A<0>) R81.1(A<0>) R90.1(A<0>) R91.1(A<0>) R109.1(A<0>) R122.1(A<0>) R124.1(A<0>) R136.1(A<0>) R137.1(A<0>) R144.1(A<0>) R155.1(A<0>) R157.1(A<0>) R159.1(A<0>) R167.1(A<0>) R172.1(A<0>) R188.1(A<0>) R190.1(A<0>) R203.1(A<0>) R208.1(A<0>) R224.1(A<0>) R226.1(A<0>) R239.1(A<0>) R244.1(A<0>) R260.1(A<0>) R262.1(A<0>) R270.1(A<0>) R271.1(A<0>) R272.1(A<0>) R310.1(A<0>) R312.1(A<0>) R313.1(A<0>) R315.1(A<0>) R317.1(A<0>) R318.1(A<0>) SK2.9(SHIELD1) SK2.10(SHIELD2) SK4.GND1 SK4.GND2 SK4.GND3 SK4.GND4 SK4.GND5 SK4.GND6 SK4.GND7 SK4.GND8 SK4.GND9 SK4.GND10 SK4.GND11 SW1.1(A<0>) SW1.2(A<1>) SW2.B SW2.D TP5.1(TEST<0>) TP19.1(TEST<0>) TP24.1(TEST<0>) U1.3 U2.1(GND) U3.9(GND1) U3.20(GND2) U4.5(GND) U5.4(GND) U5.5(2A) U5.6(2B) U6.5(GND) U7.1(GND) U8.4(GND) U9.1(GND) U10.4(GND) U11.3(GND) U12.1(GND1) U12.4(GND2) U12.6(ENA*) U12.11(ENB*) U12.15(GND3) U12.18(GND4) U12.22(ENC*) U12.27(END*) U12.29(GND5) U12.32(GND6) U13.1(GND) U14.6(GND1) U14.9(OE2) U14.10(GND2) U15.2(GND) U16.6(GND1) U16.8(OE0) U16.10(GND2) U17.1(GND1) U17.4(GND2) U17.6(ENA*) U17.11(ENB*) U17.15(GND3) U17.18(GND4) U17.22(ENC*) U17.27(END*) U17.29(GND5) U17.32(GND6) U18.1(GND) U19.1(GND) U20.1(GND) U21.1(GND) U22.1(GND) U23.1(GND) U24.1(GND) U25.1(GND) U26.1(GND) U27.1(GND) U28.1(GND) U29.1(GND) U30.3(GND) U31.3(GND) U32.8(VSS) U33.A19(EXTVCC) U33.D23(SGND) U33.G1(PGND1) U33.G23(FCB) U33.H7(PGND2) U33.H9(PGND3) U33.H11(PGND4) U33.H13(PGND5) U33.H15(PGND6) U33.H17(PGND7) U33.J1(PGND8) U33.K7(PGND9) U33.K9(PGND10) U33.K11(PGND11) U33.K13(PGND12) U33.K15(PGND13) U33.K17(PGND14) U33.L2(PGND15) U33.L4(PGND16) U33.L6(PGND17) U33.L8(PGND18) U33.L10(PGND19) U33.L12(PGND20) U33.L14(PGND21) U33.L16(PGND22) U33.L18(PGND23) U33.L20(PGND24) U33.L22(PGND25) U33.M2(PGND26) U33.M4(PGND27) U33.M6(PGND28) U33.M8(PGND29) U33.M10(PGND30) U33.M12(PGND31) U33.M14(PGND32) U33.M16(PGND33) U33.M18(PGND34) U33.M20(PGND35) U33.M22(PGND36) U33.N2(PGND37) U33.N4(PGND38) U33.N6(PGND39) U33.N8(PGND40) U33.N10(PGND41) U33.N12(PGND42) U33.N14(PGND43) U33.N16(PGND44) U33.N18(PGND45) U33.N20(PGND46) U33.N22(PGND47) U34.4(GND) U35.4(GND) U36.1(GND) U37.1(GND) U38.1(GND) U39.1(GND) U40.1(GND) U41.1(GND) U42.1(GND) U43.1(GND) U44.1(GND) U45.1(GND) U46.1(GND) U47.1(GND) U48.1(GND) U49.1(GND) U50.1(GND) U51.1(GND) U52.1(GND) U53.1(GND) U54.1(GND) U55.1(GND) U56.1(GND) U57.1(GND) U58.1(GND) U59.1(GND) U59.21(OE/DM2*) U60.1(GND) U60.21(OE/DM2*)
CLK_4_5_FPGA: PL9.E1(PAIR21_A) R31.2(B<0>) TP18.1(TEST<0>)
CLK_4_5_MAIN: R30.2(B<0>) U3.7(ICLK)
CLK_99: R3.2(B<0>) U3.8(FBIN) U10.2(DIN1) U10.3(DIN2)
CLK_99_S: PL9.E2(PAIR22_A) R5.2(B<0>) TP12.1(TEST<0>)
CLK_EC_RTM: TP13.1(TEST<0>) U4.7(ROUT1) U5.2(1B) U8.1(IN) U14.5(INB)
CLK_EC_RTM_N: PL9.B3(PAIR3_B) R273.1(A<0>) U4.1(RIN1*)
CLK_EC_RTM_P: PL9.A3(PAIR3_A) R273.2(B<0>) U4.2(RIN1)
CLK_LA_N: SK4.2LA U12.35(D3Z)
CLK_LA_P: SK4.1LA U12.36(D3Y)
CLK_LB_N: SK4.2LB U12.39(D1Z)
CLK_LB_P: SK4.1LB U12.40(D1Y)
CLK_LC_N: SK4.2LC U12.43(C3Z)
CLK_LC_P: SK4.1LC U12.44(C3Y)
CLK_LD_N: SK4.2LD U12.47(C1Z)
CLK_LD_P: SK4.1LD U12.48(C1Y)
CLK_LE_N: SK4.2LE U12.51(B3Z)
CLK_LE_P: SK4.1LE U12.52(B3Y)
CLK_LF_N: SK4.2LF U12.55(B1Z)
CLK_LF_P: SK4.1LF U12.56(B1Y)
CLK_LG_N: SK4.2LG U12.59(A3Z)
CLK_LG_P: SK4.1LG U12.60(A3Y)
CLK_LH_N: SK4.2LH U12.63(A1Z)
CLK_LH_P: SK4.1LH U12.64(A1Y)
CLK_UA_N: SK4.2UA TP16.1(TEST<0>) U12.33(D4Z)
CLK_UA_P: SK4.1UA TP15.1(TEST<0>) U12.34(D4Y)
CLK_UB_N: SK4.2UB U12.37(D2Z)
CLK_UB_P: SK4.1UB U12.38(D2Y)
CLK_UC_N: SK4.2UC U12.41(C4Z)
CLK_UC_P: SK4.1UC U12.42(C4Y)
CLK_UD_N: SK4.2UD U12.45(C2Z)
CLK_UD_P: SK4.1UD U12.46(C2Y)
CLK_UE_N: SK4.2UE U12.49(B4Z)
CLK_UE_P: SK4.1UE U12.50(B4Y)
CLK_UF_N: SK4.2UF U12.53(B2Z)
CLK_UF_P: SK4.1UF U12.54(B2Y)
CLK_UG_N: SK4.2UG U12.57(A4Z)
CLK_UG_P: SK4.1UG U12.58(A4Y)
CLK_UH_N: SK4.2UH U12.61(A2Z)
CLK_UH_P: SK4.1UH U12.62(A2Y)
DATA_LA_N: SK4.5LA U17.35(D3Z)
DATA_LA_P: SK4.4LA U17.36(D3Y)
DATA_LB_N: SK4.5LB U17.39(D1Z)
DATA_LB_P: SK4.4LB U17.40(D1Y)
DATA_LC_N: SK4.5LC U17.43(C3Z)
DATA_LC_P: SK4.4LC U17.44(C3Y)
DATA_LD_N: SK4.5LD U17.47(C1Z)
DATA_LD_P: SK4.4LD U17.48(C1Y)
DATA_LE_N: SK4.5LE U17.51(B3Z)
DATA_LE_P: SK4.4LE U17.52(B3Y)
DATA_LF_N: SK4.5LF U17.55(B1Z)
DATA_LF_P: SK4.4LF U17.56(B1Y)
DATA_LG_N: SK4.5LG U17.59(A3Z)
DATA_LG_P: SK4.4LG U17.60(A3Y)
DATA_LH_N: SK4.5LH U17.63(A1Z)
DATA_LH_P: SK4.4LH U17.64(A1Y)
DATA_UA_N: SK4.5UA TP22.1(TEST<0>) U17.33(D4Z)
DATA_UA_P: SK4.4UA TP21.1(TEST<0>) U17.34(D4Y)
DATA_UB_N: SK4.5UB U17.37(D2Z)
DATA_UB_P: SK4.4UB U17.38(D2Y)
DATA_UC_N: SK4.5UC U17.41(C4Z)
DATA_UC_P: SK4.4UC U17.42(C4Y)
DATA_UD_N: SK4.5UD U17.45(C2Z)
DATA_UD_P: SK4.4UD U17.46(C2Y)
DATA_UE_N: SK4.5UE U17.49(B4Z)
DATA_UE_P: SK4.4UE U17.50(B4Y)
DATA_UF_N: SK4.5UF U17.53(B2Z)
DATA_UF_P: SK4.4UF U17.54(B2Y)
DATA_UG_N: SK4.5UG U17.57(A4Z)
DATA_UG_P: SK4.4UG U17.58(A4Y)
DATA_UH_N: SK4.5UH U17.61(A2Z)
DATA_UH_P: SK4.4UH U17.62(A2Y)
DIV2: R1.2(B<0>) U3.3(DIV2)
DRIVE_ST: PL1.2(B<0>) U3.11(2XDRIVE)
ENABLE: R140.1(A<0>) U31.2(A) U32.5(P1)
FAILURE_LED: DS1.2(K1) R143.1(A<0>) U32.9(P4)
FAST_CLK_FPGA_N: PL9.D3(PAIR13_B) U13.7(OUT-)
FAST_CLK_FPGA_P: PL9.C3(PAIR13_A) U13.6(OUT+)
FAST_DATA_N: PL10.B3(PAIR3_B) R67.1(A<0>) U17.20(B)
FAST_DATA_P: PL10.A3(PAIR3_A) R67.2(B<0>) U17.19(A)
FPGA_F0: PL10.B7(PAIR7_B) U3.12(F0)
FPGA_F1: PL10.A8(PAIR8_A) U3.13(F1)
FPGA_F2: PL10.B8(PAIR8_B) U3.14(F2)
FPGA_F3: PL10.A9(PAIR9_A) U3.15(F3)
FPGA_F4: PL10.B9(PAIR9_B) U3.16(F4)
FPGA_F5: PL10.A10(PAIR10_A) U3.17(F5)
FPGA_F6: PL10.B10(PAIR10_B) U3.18(F6)
FPGA_R0: PL10.A4(PAIR4_A) U3.24(R0)
FPGA_R1: PL10.B4(PAIR4_B) U3.25(R1)
FPGA_R2: PL10.A5(PAIR5_A) U3.26(R2)
FPGA_R3: PL10.B5(PAIR5_B) U3.27(R3)
FPGA_R4: PL10.A6(PAIR6_A) U3.28(R4)
FPGA_R5: PL10.B6(PAIR6_B) U3.1(R5)
FPGA_R6: PL10.A7(PAIR7_A) U3.2(R6)
FPGA_SPARE_IN1_I_N: C34.2(B<0>) C36.1(A<0>) R82.2(B<0>) SK2.2
FPGA_SPARE_IN1_I_P: C32.2(B<0>) C37.1(A<0>) R82.1(A<0>) SK2.1
FPGA_SPARE_IN1_N: PL10.B2(PAIR2_B) R96.2(B<0>) U18.7(OUT-) U20.2(IN-)
FPGA_SPARE_IN1_P: PL10.A2(PAIR2_A) R96.1(A<0>) U18.6(OUT+) U20.3(IN+)
FPGA_SPARE_IN2_I_N: C35.2(B<0>) C38.1(A<0>) R83.2(B<0>) SK2.5
FPGA_SPARE_IN2_I_P: C33.2(B<0>) C39.1(A<0>) R83.1(A<0>) SK2.4
FPGA_SPARE_IN2_N: PL9.B10(PAIR10_B) R97.2(B<0>) U19.7(OUT-) U21.2(IN-)
FPGA_SPARE_IN2_P: PL9.A10(PAIR10_A) R97.1(A<0>) U19.6(OUT+) U21.3(IN+)
FPGA_SPARE_OUT1_I_N: SK2.8 U22.7(OUT-)
FPGA_SPARE_OUT1_I_P: SK2.7 U22.6(OUT+)
FPGA_SPARE_OUT1_N: PL10.B1(PAIR1_B) R100.1(A<0>) U22.3(IN+)
FPGA_SPARE_OUT1_P: PL10.A1(PAIR1_A) R100.2(B<0>) U22.2(IN-)
FPGA_SPARE_OUT2_I_N: SK2.6 U23.7(OUT-)
FPGA_SPARE_OUT2_I_P: SK2.3 U23.6(OUT+)
FPGA_SPARE_OUT2_N: PL9.B9(PAIR9_B) R101.2(B<0>) U23.2(IN-)
FPGA_SPARE_OUT2_P: PL9.A9(PAIR9_A) R101.1(A<0>) U23.3(IN+)
HSWAP_LED: R146.1(A<0>) U32.11(P6)
I2C_SCL: PL9.D2(PAIR12_B) R150.1(A<0>) TP8.1(TEST<0>) U32.14(SCL) U34.6(SCL) U35.2(SCL)
I2C_SDA: PL9.D1(PAIR11_B) R149.1(A<0>) TP7.1(TEST<0>) U32.15(SDA) U34.5(SDA) U35.1(SDA)
LED_LA_1: SK4.LLLA_K U59.5(OUT0)
LED_LA_2: SK4.LRLA_K U59.6(OUT1)
LED_LB_1: SK4.LLLB_K U59.9(OUT4)
LED_LB_2: SK4.LRLB_K U59.10(OUT5)
LED_LC_1: SK4.LLLC_K U59.13(OUT8)
LED_LC_2: SK4.LRLC_K U59.14(OUT9)
LED_LD_1: SK4.LLLD_K U59.17(OUT12)
LED_LD_2: SK4.LRLD_K U59.18(OUT13)
LED_LE_1: SK4.LLLE_K U60.13(OUT8)
LED_LE_2: SK4.LRLE_K U60.14(OUT9)
LED_LE_A: PL10.D1(PAIR11_B) U59.4(LE/DM1)
LED_LE_B: PL10.F10(PAIR30_B) U60.4(LE/DM1)
LED_LF_1: SK4.LLLF_K U60.17(OUT12)
LED_LF_2: SK4.LRLF_K U60.18(OUT13)
LED_LG_1: SK4.LLLG_K U60.5(OUT0)
LED_LG_2: SK4.LRLG_K U60.6(OUT1)
LED_LH_1: SK4.LLLH_K U60.9(OUT4)
LED_LH_2: SK4.LRLH_K U60.10(OUT5)
LED_SCL: PL10.C2(PAIR12_A) U59.3(CLK) U60.3(CLK)
LED_SDI_A: PL10.C1(PAIR11_A) TP20.1(TEST<0>) U59.2(SDI)
LED_SDI_B: PL10.E10(PAIR30_A) TP23.1(TEST<0>) U60.2(SDI)
LED_UA_1: SK4.ULLA_K U59.7(OUT2)
LED_UA_2: SK4.URLA_K U59.8(OUT3)
LED_UB_1: SK4.ULLB_K U59.11(OUT6)
LED_UB_2: SK4.URLB_K U59.12(OUT7)
LED_UC_1: SK4.ULLC_K U59.15(OUT10)
LED_UC_2: SK4.URLC_K U59.16(OUT11)
LED_UD_1: SK4.ULLD_K U59.19(OUT14)
LED_UD_2: SK4.URLD_K U59.20(OUT15)
LED_UE_1: SK4.ULLE_K U60.15(OUT10)
LED_UE_2: SK4.URLE_K U60.16(OUT11)
LED_UF_1: SK4.ULLF_K U60.19(OUT14)
LED_UF_2: SK4.URLF_K U60.20(OUT15)
LED_UG_1: SK4.ULLG_K U60.7(OUT2)
LED_UG_2: SK4.URLG_K U60.8(OUT3)
LED_UH_1: SK4.ULLH_K U60.11(OUT6)
LED_UH_2: SK4.URLH_K U60.12(OUT7)
NO_4_5_MHZ: PL9.A4(PAIR4_A) U14.11(NO_INB)
NO_9_MHZ: PL9.B4(PAIR4_B) U14.12(NO_INA)
PGOOD: R139.1(A<0>) U1.4(Y) U32.4(P0)
RESET: R141.1(A<0>) U32.6(P2)
RUN_SS_DC: R135.1(A<0>) R136.2(B<0>) U31.4(Y) U33.F23(RUN/SS)
STATUS_LA_N: C19.2(B<0>) C22.1(A<0>) R20.2(B<0>) SK4.6LA
STATUS_LA_P: C18.2(B<0>) C23.1(A<0>) R20.1(A<0>) SK4.3LA
STATUS_LB_N: C69.2(B<0>) C73.1(A<0>) R114.2(B<0>) SK4.6LB
STATUS_LB_P: C66.2(B<0>) C74.1(A<0>) R114.1(A<0>) SK4.3LB
STATUS_LC_N: C56.2(B<0>) C59.1(A<0>) R104.2(B<0>) SK4.6LC
STATUS_LC_P: C53.2(B<0>) C60.1(A<0>) R104.1(A<0>) SK4.3LC
STATUS_LD_N: C68.2(B<0>) C71.1(A<0>) R113.2(B<0>) SK4.6LD
STATUS_LD_P: C65.2(B<0>) C72.1(A<0>) R113.1(A<0>) SK4.3LD
STATUS_LE_N: C100.2(B<0>) C104.1(A<0>) R162.2(B<0>) SK4.6LE
STATUS_LE_P: C97.2(B<0>) C105.1(A<0>) R162.1(A<0>) SK4.3LE
STATUS_LF_N: C113.2(B<0>) C118.1(A<0>) R180.2(B<0>) SK4.6LF
STATUS_LF_P: C111.2(B<0>) C119.1(A<0>) R180.1(A<0>) SK4.3LF
STATUS_LG_N: C98.2(B<0>) C102.1(A<0>) R161.2(B<0>) SK4.6LG
STATUS_LG_P: C94.2(B<0>) C103.1(A<0>) R161.1(A<0>) SK4.3LG
STATUS_LH_N: C112.2(B<0>) C116.1(A<0>) R179.2(B<0>) SK4.6LH
STATUS_LH_P: C110.2(B<0>) C117.1(A<0>) R179.1(A<0>) SK4.3LH
STATUS_OUT_LA_N: PL10.F1(PAIR21_B) R37.2(B<0>) U7.7(OUT-) U9.2(IN-)
STATUS_OUT_LA_P: PL10.E1(PAIR21_A) R37.1(A<0>) U7.6(OUT+) U9.3(IN+)
STATUS_OUT_LB_N: PL10.F3(PAIR23_B) R128.2(B<0>) U27.7(OUT-) U29.2(IN-)
STATUS_OUT_LB_P: PL10.E3(PAIR23_A) R128.1(A<0>) U27.6(OUT+) U29.3(IN+)
STATUS_OUT_LC_N: PL10.F5(PAIR25_B) R111.2(B<0>) U24.7(OUT-) U25.2(IN-)
STATUS_OUT_LC_P: PL10.E5(PAIR25_A) R111.1(A<0>) U24.6(OUT+) U25.3(IN+)
STATUS_OUT_LD_N: PL10.F7(PAIR27_B) R127.2(B<0>) U26.7(OUT-) U28.2(IN-)
STATUS_OUT_LD_P: PL10.E7(PAIR27_A) R127.1(A<0>) U26.6(OUT+) U28.3(IN+)
STATUS_OUT_LE_N: PL10.F9(PAIR29_B) R176.2(B<0>) U37.7(OUT-) U39.2(IN-)
STATUS_OUT_LE_P: PL10.E9(PAIR29_A) R176.1(A<0>) U37.6(OUT+) U39.3(IN+)
STATUS_OUT_LF_N: PL9.F4(PAIR24_B) R194.2(B<0>) U41.7(OUT-) U43.2(IN-)
STATUS_OUT_LF_P: PL9.E4(PAIR24_A) R194.1(A<0>) U41.6(OUT+) U43.3(IN+)
STATUS_OUT_LG_N: PL9.F6(PAIR26_B) R175.2(B<0>) U36.7(OUT-) U38.2(IN-)
STATUS_OUT_LG_P: PL9.E6(PAIR26_A) R175.1(A<0>) U36.6(OUT+) U38.3(IN+)
STATUS_OUT_LH_N: PL9.F8(PAIR28_B) R193.2(B<0>) U40.7(OUT-) U42.2(IN-)
STATUS_OUT_LH_P: PL9.E8(PAIR28_A) R193.1(A<0>) U40.6(OUT+) U42.3(IN+)
STATUS_OUT_UA_N: PL10.F2(PAIR22_B) R248.2(B<0>) U2.7(OUT-) U54.2(IN-)
STATUS_OUT_UA_P: PL10.E2(PAIR22_A) R248.1(A<0>) U2.6(OUT+) U54.3(IN+)
STATUS_OUT_UB_N: PL10.F4(PAIR24_B) R266.2(B<0>) U56.7(OUT-) U58.2(IN-)
STATUS_OUT_UB_P: PL10.E4(PAIR24_A) R266.1(A<0>) U56.6(OUT+) U58.3(IN+)
STATUS_OUT_UC_N: PL10.F6(PAIR26_B) R247.2(B<0>) U52.7(OUT-) U53.2(IN-)
STATUS_OUT_UC_P: PL10.E6(PAIR26_A) R247.1(A<0>) U52.6(OUT+) U53.3(IN+)
STATUS_OUT_UD_N: PL10.F8(PAIR28_B) R265.2(B<0>) U55.7(OUT-) U57.2(IN-)
STATUS_OUT_UD_P: PL10.E8(PAIR28_A) R265.1(A<0>) U55.6(OUT+) U57.3(IN+)
STATUS_OUT_UE_N: PL9.F3(PAIR23_B) R212.2(B<0>) U45.7(OUT-) U47.2(IN-)
STATUS_OUT_UE_P: PL9.E3(PAIR23_A) R212.1(A<0>) U45.6(OUT+) U47.3(IN+)
STATUS_OUT_UF_N: PL9.F5(PAIR25_B) R230.2(B<0>) U49.7(OUT-) U51.2(IN-)
STATUS_OUT_UF_P: PL9.E5(PAIR25_A) R230.1(A<0>) U49.6(OUT+) U51.3(IN+)
STATUS_OUT_UG_N: PL9.F7(PAIR27_B) R211.2(B<0>) U44.7(OUT-) U46.2(IN-)
STATUS_OUT_UG_P: PL9.E7(PAIR27_A) R211.1(A<0>) U44.6(OUT+) U46.3(IN+)
STATUS_OUT_UH_N: PL9.F9(PAIR29_B) R229.2(B<0>) TP4.1(TEST<0>) U48.7(OUT-) U50.2(IN-)
STATUS_OUT_UH_P: PL9.E9(PAIR29_A) R229.1(A<0>) TP3.1(TEST<0>) U48.6(OUT+) U50.3(IN+)
STATUS_UA_N: C155.2(B<0>) C160.1(A<0>) R234.2(B<0>) SK4.6UA
STATUS_UA_P: C153.2(B<0>) C161.1(A<0>) R234.1(A<0>) SK4.3UA
STATUS_UB_N: C169.2(B<0>) C174.1(A<0>) R252.2(B<0>) SK4.6UB
STATUS_UB_P: C167.2(B<0>) C175.1(A<0>) R252.1(A<0>) SK4.3UB
STATUS_UC_N: C154.2(B<0>) C158.1(A<0>) R233.2(B<0>) SK4.6UC
STATUS_UC_P: C150.2(B<0>) C159.1(A<0>) R233.1(A<0>) SK4.3UC
STATUS_UD_N: C168.2(B<0>) C172.1(A<0>) R251.2(B<0>) SK4.6UD
STATUS_UD_P: C165.2(B<0>) C173.1(A<0>) R251.1(A<0>) SK4.3UD
STATUS_UE_N: C127.2(B<0>) C132.1(A<0>) R198.2(B<0>) SK4.6UE
STATUS_UE_P: C125.2(B<0>) C133.1(A<0>) R198.1(A<0>) SK4.3UE
STATUS_UF_N: C141.2(B<0>) C146.1(A<0>) R216.2(B<0>) SK4.6UF
STATUS_UF_P: C139.2(B<0>) C147.1(A<0>) R216.1(A<0>) SK4.3UF
STATUS_UG_N: C126.2(B<0>) C130.1(A<0>) R197.2(B<0>) SK4.6UG
STATUS_UG_P: C122.2(B<0>) C131.1(A<0>) R197.1(A<0>) SK4.3UG
STATUS_UH_N: C140.2(B<0>) C144.1(A<0>) R215.2(B<0>) SK4.6UH TP1.1(TEST<0>)
STATUS_UH_P: C137.2(B<0>) C145.1(A<0>) R215.1(A<0>) SK4.3UH TP2.1(TEST<0>)
SW_HOT_SWAP: DS5.2(K1) R142.1(A<0>) SW2.A SW2.C U32.7(P3)
UNNAMED_1_CAPACITOR_I90_B: C36.2(B<0>) R84.1(A<0>) R85.2(B<0>) R92.1(A<0>) U18.2(IN-)
UNNAMED_1_CAPACITOR_I99_B: C37.2(B<0>) R85.1(A<0>) R86.2(B<0>) R90.2(B<0>) U18.3(IN+)
UNNAMED_1_CAPACITOR_I100_B: C38.2(B<0>) R87.1(A<0>) R88.2(B<0>) R93.1(A<0>) U19.2(IN-)
UNNAMED_1_CAPACITOR_I101_B: C39.2(B<0>) R88.1(A<0>) R89.2(B<0>) R91.2(B<0>) U19.3(IN+)
UNNAMED_1_DS90LV001_I70_EN: R102.1(A<0>) U22.8(EN)
UNNAMED_1_DS90LV001_I71_EN: R103.1(A<0>) U23.8(EN)
UNNAMED_1_DS90LV001_I78_EN: R94.1(A<0>) U18.8(EN)
UNNAMED_1_DS90LV001_I79_EN: R98.1(A<0>) U20.8(EN)
UNNAMED_1_DS90LV001_I79_OUT: R86.1(A<0>) U20.6(OUT+)
UNNAMED_1_DS90LV001_I79_OUT_1: R84.2(B<0>) U20.7(OUT-)
UNNAMED_1_DS90LV001_I80_EN: R99.1(A<0>) U21.8(EN)
UNNAMED_1_DS90LV001_I80_OUT: R89.1(A<0>) U21.6(OUT+)
UNNAMED_1_DS90LV001_I80_OUT_1: R87.2(B<0>) U21.7(OUT-)
UNNAMED_1_DS90LV001_I81_EN: R95.1(A<0>) U19.8(EN)
UNNAMED_2_CAPACITOR_I8_B: C22.2(B<0>) R24.1(A<0>) R25.2(B<0>) R27.1(A<0>) U7.2(IN-)
UNNAMED_2_CAPACITOR_I25_B: C23.2(B<0>) R25.1(A<0>) R26.2(B<0>) R28.2(B<0>) U7.3(IN+)
UNNAMED_2_CAPACITOR_I157_B: C73.2(B<0>) R118.1(A<0>) R119.2(B<0>) R123.1(A<0>) U27.2(IN-)
UNNAMED_2_CAPACITOR_I170_B: C74.2(B<0>) R119.1(A<0>) R120.2(B<0>) R124.2(B<0>) U27.3(IN+)
UNNAMED_2_CAPACITOR_I189_B: C59.2(B<0>) R105.1(A<0>) R106.2(B<0>) R108.1(A<0>) U24.2(IN-)
UNNAMED_2_CAPACITOR_I190_B: C60.2(B<0>) R106.1(A<0>) R107.2(B<0>) R109.2(B<0>) U24.3(IN+)
UNNAMED_2_CAPACITOR_I209_B: C71.2(B<0>) R115.1(A<0>) R116.2(B<0>) R121.1(A<0>) U26.2(IN-)
UNNAMED_2_CAPACITOR_I210_B: C72.2(B<0>) R116.1(A<0>) R117.2(B<0>) R122.2(B<0>) U26.3(IN+)
UNNAMED_2_DS90LV001_I18_EN: R35.1(A<0>) U7.8(EN)
UNNAMED_2_DS90LV001_I19_EN: R39.1(A<0>) U9.8(EN)
UNNAMED_2_DS90LV001_I19_OUT: R24.2(B<0>) U9.7(OUT-)
UNNAMED_2_DS90LV001_I19_OUT_1: R26.1(A<0>) U9.6(OUT+)
UNNAMED_2_DS90LV001_I162_EN: R130.1(A<0>) U29.8(EN)
UNNAMED_2_DS90LV001_I162_OUT: R118.2(B<0>) U29.7(OUT-)
UNNAMED_2_DS90LV001_I162_OUT_1: R120.1(A<0>) U29.6(OUT+)
UNNAMED_2_DS90LV001_I166_EN: R126.1(A<0>) U27.8(EN)
UNNAMED_2_DS90LV001_I181_EN: R112.1(A<0>) U25.8(EN)
UNNAMED_2_DS90LV001_I181_OUT: R107.1(A<0>) U25.6(OUT+)
UNNAMED_2_DS90LV001_I181_OUT_1: R105.2(B<0>) U25.7(OUT-)
UNNAMED_2_DS90LV001_I185_EN: R110.1(A<0>) U24.8(EN)
UNNAMED_2_DS90LV001_I201_EN: R129.1(A<0>) U28.8(EN)
UNNAMED_2_DS90LV001_I201_OUT: R115.2(B<0>) U28.7(OUT-)
UNNAMED_2_DS90LV001_I201_OUT_1: R117.1(A<0>) U28.6(OUT+)
UNNAMED_2_DS90LV001_I205_EN: R125.1(A<0>) U26.8(EN)
UNNAMED_4_CAPACITOR_I14_B: C159.2(B<0>) R236.1(A<0>) R237.2(B<0>) R239.2(B<0>) U52.3(IN+)
UNNAMED_4_CAPACITOR_I15_B: C158.2(B<0>) R235.1(A<0>) R236.2(B<0>) R238.1(A<0>) U52.2(IN-)
UNNAMED_4_CAPACITOR_I30_B: C161.2(B<0>) R241.1(A<0>) R242.2(B<0>) R244.2(B<0>) U2.3(IN+)
UNNAMED_4_CAPACITOR_I31_B: C160.2(B<0>) R240.1(A<0>) R241.2(B<0>) R243.1(A<0>) U2.2(IN-)
UNNAMED_4_CAPACITOR_I61_B: C173.2(B<0>) R254.1(A<0>) R255.2(B<0>) R260.2(B<0>) U55.3(IN+)
UNNAMED_4_CAPACITOR_I62_B: C172.2(B<0>) R253.1(A<0>) R254.2(B<0>) R259.1(A<0>) U55.2(IN-)
UNNAMED_4_CAPACITOR_I79_B: C175.2(B<0>) R257.1(A<0>) R258.2(B<0>) R262.2(B<0>) U56.3(IN+)
UNNAMED_4_CAPACITOR_I80_B: C174.2(B<0>) R256.1(A<0>) R257.2(B<0>) R261.1(A<0>) U56.2(IN-)
UNNAMED_4_DS90LV001_I18_EN: R245.1(A<0>) U52.8(EN)
UNNAMED_4_DS90LV001_I38_EN: R249.1(A<0>) U53.8(EN)
UNNAMED_4_DS90LV001_I38_OUT: R235.2(B<0>) U53.7(OUT-)
UNNAMED_4_DS90LV001_I38_OUT_1: R237.1(A<0>) U53.6(OUT+)
UNNAMED_4_DS90LV001_I39_EN: R246.1(A<0>) U2.8(EN)
UNNAMED_4_DS90LV001_I43_EN: R250.1(A<0>) U54.8(EN)
UNNAMED_4_DS90LV001_I43_OUT: R242.1(A<0>) U54.6(OUT+)
UNNAMED_4_DS90LV001_I43_OUT_1: R240.2(B<0>) U54.7(OUT-)
UNNAMED_4_DS90LV001_I68_EN: R263.1(A<0>) U55.8(EN)
UNNAMED_4_DS90LV001_I85_EN: R264.1(A<0>) U56.8(EN)
UNNAMED_4_DS90LV001_I90_EN: R267.1(A<0>) U57.8(EN)
UNNAMED_4_DS90LV001_I90_OUT: R253.2(B<0>) U57.7(OUT-)
UNNAMED_4_DS90LV001_I90_OUT_1: R255.1(A<0>) U57.6(OUT+)
UNNAMED_4_DS90LV001_I94_EN: R268.1(A<0>) U58.8(EN)
UNNAMED_4_DS90LV001_I94_OUT: R256.2(B<0>) U58.7(OUT-)
UNNAMED_4_DS90LV001_I94_OUT_1: R258.1(A<0>) U58.6(OUT+)
UNNAMED_5_CAPACITOR_I14_B: C131.2(B<0>) R200.1(A<0>) R201.2(B<0>) R203.2(B<0>) U44.3(IN+)
UNNAMED_5_CAPACITOR_I15_B: C130.2(B<0>) R199.1(A<0>) R200.2(B<0>) R202.1(A<0>) U44.2(IN-)
UNNAMED_5_CAPACITOR_I30_B: C133.2(B<0>) R205.1(A<0>) R206.2(B<0>) R208.2(B<0>) U45.3(IN+)
UNNAMED_5_CAPACITOR_I31_B: C132.2(B<0>) R204.1(A<0>) R205.2(B<0>) R207.1(A<0>) U45.2(IN-)
UNNAMED_5_CAPACITOR_I61_B: C145.2(B<0>) R218.1(A<0>) R219.2(B<0>) R224.2(B<0>) U48.3(IN+)
UNNAMED_5_CAPACITOR_I62_B: C144.2(B<0>) R217.1(A<0>) R218.2(B<0>) R223.1(A<0>) U48.2(IN-)
UNNAMED_5_CAPACITOR_I79_B: C147.2(B<0>) R221.1(A<0>) R222.2(B<0>) R226.2(B<0>) U49.3(IN+)
UNNAMED_5_CAPACITOR_I80_B: C146.2(B<0>) R220.1(A<0>) R221.2(B<0>) R225.1(A<0>) U49.2(IN-)
UNNAMED_5_DS90LV001_I18_EN: R209.1(A<0>) U44.8(EN)
UNNAMED_5_DS90LV001_I38_EN: R213.1(A<0>) U46.8(EN)
UNNAMED_5_DS90LV001_I38_OUT: R201.1(A<0>) U46.6(OUT+)
UNNAMED_5_DS90LV001_I38_OUT_1: R199.2(B<0>) U46.7(OUT-)
UNNAMED_5_DS90LV001_I39_EN: R210.1(A<0>) U45.8(EN)
UNNAMED_5_DS90LV001_I43_EN: R214.1(A<0>) U47.8(EN)
UNNAMED_5_DS90LV001_I43_OUT: R206.1(A<0>) U47.6(OUT+)
UNNAMED_5_DS90LV001_I43_OUT_1: R204.2(B<0>) U47.7(OUT-)
UNNAMED_5_DS90LV001_I68_EN: R227.1(A<0>) U48.8(EN)
UNNAMED_5_DS90LV001_I85_EN: R228.1(A<0>) U49.8(EN)
UNNAMED_5_DS90LV001_I90_EN: R231.1(A<0>) U50.8(EN)
UNNAMED_5_DS90LV001_I90_OUT: R219.1(A<0>) U50.6(OUT+)
UNNAMED_5_DS90LV001_I90_OUT_1: R217.2(B<0>) U50.7(OUT-)
UNNAMED_5_DS90LV001_I94_EN: R232.1(A<0>) U51.8(EN)
UNNAMED_5_DS90LV001_I94_OUT: R222.1(A<0>) U51.6(OUT+)
UNNAMED_5_DS90LV001_I94_OUT_1: R220.2(B<0>) U51.7(OUT-)
UNNAMED_6_74LVC1G34_I76_Y: R134.1(A<0>) U1.2(A) U30.4(Y)
UNNAMED_6_AT24C32C_I14_A0: R314.1(A<0>) R315.2(B<0>) U34.1(A0)
UNNAMED_6_AT24C32C_I14_A1: R316.1(A<0>) R317.2(B<0>) U34.2(A1)
UNNAMED_6_AT24C32C_I14_A2: R148.1(A<0>) R318.2(B<0>) U34.3(A2)
UNNAMED_6_CAPACITOR_I59_B: C81.2(B<0>) R137.2(B<0>) U33.A15(FADJ)
UNNAMED_6_CAPACITOR_I62_A: C82.1(A<0>) R144.2(B<0>) U33.A21(VOSET)
UNNAMED_6_LED-SMD_I19_A1: DS5.1(A1) R151.2(B<0>)
UNNAMED_6_LED-SMD_I21_A1: DS6.1(A1) R152.2(B<0>)
UNNAMED_6_LED-SMD_I22_A1: DS1.1(A1) R153.2(B<0>)
UNNAMED_6_LED-SMD_I70_A1: DS3.1(A1) R132.2(B<0>)
UNNAMED_6_LED-SMD_I71_A1: DS2.1(A1) R131.2(B<0>)
UNNAMED_6_LED-SMD_I81_A1: DS4.1(A1) R134.2(B<0>)
UNNAMED_6_LM75A_I38_A0: R158.1(A<0>) R159.2(B<0>) U35.7(A0)
UNNAMED_6_LM75A_I38_A1: R156.1(A<0>) R157.2(B<0>) U35.6(A1)
UNNAMED_6_LM75A_I38_A2: R154.1(A<0>) R155.2(B<0>) U35.5(A2)
UNNAMED_6_LM75A_I38_OS: R160.1(A<0>) U35.3(OS)
UNNAMED_6_PCF8574_I3_A0: R138.1(A<0>) R313.2(B<0>) U32.1(A0)
UNNAMED_6_PCF8574_I3_A1: R311.1(A<0>) R312.2(B<0>) U32.2(A1)
UNNAMED_6_PCF8574_I3_A2: R309.1(A<0>) R310.2(B<0>) U32.3(A2)
UNNAMED_6_RESISTOR_I107_B: PL9.C1(PAIR11_A) R270.2(B<0>)
UNNAMED_7_2WAY-SPST_I62_B: SW1.3(B<1>) U14.1(SELB)
UNNAMED_7_2WAY-SPST_I62_B_1: SW1.4(B<0>) U14.16(OE1)
UNNAMED_7_3D3225_I154_OUT5: U5.1(1A) U8.5(OUT5)
UNNAMED_7_65LVDS116_I76_A: R21.2(B<0>) R269.2(B<0>) U10.7(DOUT1) U12.19(A) U13.2(IN-)
UNNAMED_7_65LVDS116_I76_B: R21.1(A<0>) R269.1(A<0>) U10.8(DOUT1*) U12.20(B) U13.3(IN+)
UNNAMED_7_65LVDS116_I76_ENA: R12.1(A<0>) R13.2(B<0>) U12.5(ENA)
UNNAMED_7_65LVDS116_I76_ENB: R10.1(A<0>) R11.2(B<0>) U12.10(ENB)
UNNAMED_7_65LVDS116_I76_ENC: R8.1(A<0>) R9.2(B<0>) U12.23(ENC)
UNNAMED_7_65LVDS116_I76_END: R6.1(A<0>) R7.2(B<0>) U12.28(END)
UNNAMED_7_65LVDS116_I76_S0: R18.1(A<0>) R19.2(B<0>) U12.24(S0)
UNNAMED_7_65LVDS116_I76_S1: R16.1(A<0>) R17.2(B<0>) U12.25(S1)
UNNAMED_7_65LVDS116_I76_SM: R14.1(A<0>) R15.2(B<0>) U12.26(SM)
UNNAMED_7_74LVC1G06_I51_A: U5.7(1Y) U11.2(A)
UNNAMED_7_74LVC1G06_I51_Y: TP14.1(TEST<0>) U11.4(Y) U14.4(INA)
UNNAMED_7_DS90LV001_I121_EN: R23.1(A<0>) U13.8(EN)
UNNAMED_7_DS90LV018A_I104_RIN1: R4.2(B<0>) TP11.1(TEST<0>) U6.2(RIN1) U10.6(DOUT2)
UNNAMED_7_DS90LV018A_I104_RIN1_: R4.1(A<0>) TP10.1(TEST<0>) U6.1(RIN1*) U10.5(DOUT2*)
UNNAMED_7_DS90LV018A_I104_ROUT1: R5.1(A<0>) U6.7(ROUT1)
UNNAMED_7_HEADER2X1_I125_B: PL2.2(B<0>) U3.4(S0)
UNNAMED_7_HEADER2X1_I126_B: PL3.2(B<0>) U3.5(S1)
UNNAMED_7_HEADER2X1_I127_B: PL4.2(B<0>) U3.19(PDTS*)
UNNAMED_7_HEADER2X1_I149_B: PL6.2(B<0>) U16.1(S0)
UNNAMED_7_HEADER2X1_I150_B: PL7.2(B<0>) U16.2(S1)
UNNAMED_7_HEADER2X1_I151_B: PL5.2(B<0>) U16.16(DIV)
UNNAMED_7_ICS527-01_I67_CLK1: R3.1(A<0>) U3.22(CLK1)
UNNAMED_7_ICS527-01_I67_OECLK2: R2.2(B<0>) U3.10(OECLK2)
UNNAMED_7_ICS580-01_I60_CLK1: TP17.1(TEST<0>) U14.14(CLK1) U16.4(INA)
UNNAMED_7_ICS581-02_I30_CLK2: R30.1(A<0>) U16.13(CLK2)
UNNAMED_7_ICS581-02_I30_CLK3: R31.1(A<0>) U16.12(CLK3)
UNNAMED_7_ICS581-02_I30_CLK4: U16.7(FBIN) U16.11(CLK4)
UNNAMED_7_ICS581-02_I30_INB: U15.3(OUT<0>) U16.5(INB)
UNNAMED_7_ICS581-02_I30_OE1: R29.1(A<0>) U16.9(OE1)
UNNAMED_7_OSC-SMD_I36_EN: R22.1(A<0>) U15.1(EN<0>)
UNNAMED_8_65LVDS116_I16_ENA: R70.1(A<0>) R71.2(B<0>) U17.5(ENA)
UNNAMED_8_65LVDS116_I16_ENB: R68.1(A<0>) R69.2(B<0>) U17.10(ENB)
UNNAMED_8_65LVDS116_I16_ENC: R80.1(A<0>) R81.2(B<0>) U17.23(ENC)
UNNAMED_8_65LVDS116_I16_END: R78.1(A<0>) R79.2(B<0>) U17.28(END)
UNNAMED_8_65LVDS116_I16_S0: R76.1(A<0>) R77.2(B<0>) U17.24(S0)
UNNAMED_8_65LVDS116_I16_S1: R74.1(A<0>) R75.2(B<0>) U17.25(S1)
UNNAMED_8_65LVDS116_I16_SM: R72.1(A<0>) R73.2(B<0>) U17.26(SM)
UNNAMED_8_RESISTOR_I44_B: R33.2(B<0>) SK4.LRLA_A
UNNAMED_8_RESISTOR_I45_B: R34.2(B<0>) SK4.LLLB_A
UNNAMED_8_RESISTOR_I46_B: R36.2(B<0>) SK4.LRLB_A
UNNAMED_8_RESISTOR_I47_B: R38.2(B<0>) SK4.LLLC_A
UNNAMED_8_RESISTOR_I48_B: R40.2(B<0>) SK4.LRLC_A
UNNAMED_8_RESISTOR_I49_B: R41.2(B<0>) SK4.LLLD_A
UNNAMED_8_RESISTOR_I50_B: R42.2(B<0>) SK4.LRLD_A
UNNAMED_8_RESISTOR_I51_B: R43.2(B<0>) SK4.LLLE_A
UNNAMED_8_RESISTOR_I52_B: R44.2(B<0>) SK4.LRLE_A
UNNAMED_8_RESISTOR_I53_B: R45.2(B<0>) SK4.LLLF_A
UNNAMED_8_RESISTOR_I54_B: R46.2(B<0>) SK4.LRLF_A
UNNAMED_8_RESISTOR_I55_B: R47.2(B<0>) SK4.LLLG_A
UNNAMED_8_RESISTOR_I56_B: R48.2(B<0>) SK4.LRLG_A
UNNAMED_8_RESISTOR_I57_B: R49.2(B<0>) SK4.LLLH_A
UNNAMED_8_RESISTOR_I58_B: R50.2(B<0>) SK4.LRLH_A
UNNAMED_8_RESISTOR_I59_B: R32.2(B<0>) SK4.LLLA_A
UNNAMED_8_RESISTOR_I60_A: R51.1(A<0>) SK4.ULLA_A
UNNAMED_8_RESISTOR_I61_A: R52.1(A<0>) SK4.URLA_A
UNNAMED_8_RESISTOR_I62_A: R53.1(A<0>) SK4.ULLB_A
UNNAMED_8_RESISTOR_I63_A: R54.1(A<0>) SK4.URLB_A
UNNAMED_8_RESISTOR_I64_A: R55.1(A<0>) SK4.ULLC_A
UNNAMED_8_RESISTOR_I65_A: R56.1(A<0>) SK4.URLC_A
UNNAMED_8_RESISTOR_I66_A: R57.1(A<0>) SK4.ULLD_A
UNNAMED_8_RESISTOR_I67_A: R58.1(A<0>) SK4.URLD_A
UNNAMED_8_RESISTOR_I68_A: R59.1(A<0>) SK4.ULLE_A
UNNAMED_8_RESISTOR_I69_A: R60.1(A<0>) SK4.URLE_A
UNNAMED_8_RESISTOR_I70_A: R61.1(A<0>) SK4.ULLF_A
UNNAMED_8_RESISTOR_I71_A: R64.1(A<0>) SK4.URLG_A
UNNAMED_8_RESISTOR_I72_A: R65.1(A<0>) SK4.ULLH_A
UNNAMED_8_RESISTOR_I73_A: R66.1(A<0>) SK4.URLH_A
UNNAMED_8_RESISTOR_I74_A: R62.1(A<0>) SK4.URLF_A
UNNAMED_8_RESISTOR_I75_A: R63.1(A<0>) SK4.ULLG_A
UNNAMED_8_RESISTOR_I135_B: R271.2(B<0>) U59.23(REXT)
UNNAMED_8_RESISTOR_I136_B: R272.2(B<0>) U60.23(REXT)
UNNAMED_10_CAPACITOR_I14_B: C103.2(B<0>) R164.1(A<0>) R165.2(B<0>) R167.2(B<0>) U36.3(IN+)
UNNAMED_10_CAPACITOR_I15_B: C102.2(B<0>) R163.1(A<0>) R164.2(B<0>) R166.1(A<0>) U36.2(IN-)
UNNAMED_10_CAPACITOR_I30_B: C105.2(B<0>) R169.1(A<0>) R170.2(B<0>) R172.2(B<0>) U37.3(IN+)
UNNAMED_10_CAPACITOR_I31_B: C104.2(B<0>) R168.1(A<0>) R169.2(B<0>) R171.1(A<0>) U37.2(IN-)
UNNAMED_10_CAPACITOR_I61_B: C117.2(B<0>) R182.1(A<0>) R183.2(B<0>) R188.2(B<0>) U40.3(IN+)
UNNAMED_10_CAPACITOR_I62_B: C116.2(B<0>) R181.1(A<0>) R182.2(B<0>) R187.1(A<0>) U40.2(IN-)
UNNAMED_10_CAPACITOR_I79_B: C119.2(B<0>) R185.1(A<0>) R186.2(B<0>) R190.2(B<0>) U41.3(IN+)
UNNAMED_10_CAPACITOR_I80_B: C118.2(B<0>) R184.1(A<0>) R185.2(B<0>) R189.1(A<0>) U41.2(IN-)
UNNAMED_10_DS90LV001_I18_EN: R173.1(A<0>) U36.8(EN)
UNNAMED_10_DS90LV001_I38_EN: R177.1(A<0>) U38.8(EN)
UNNAMED_10_DS90LV001_I38_OUT: R165.1(A<0>) U38.6(OUT+)
UNNAMED_10_DS90LV001_I38_OUT_1: R163.2(B<0>) U38.7(OUT-)
UNNAMED_10_DS90LV001_I39_EN: R174.1(A<0>) U37.8(EN)
UNNAMED_10_DS90LV001_I43_EN: R178.1(A<0>) U39.8(EN)
UNNAMED_10_DS90LV001_I43_OUT: R170.1(A<0>) U39.6(OUT+)
UNNAMED_10_DS90LV001_I43_OUT_1: R168.2(B<0>) U39.7(OUT-)
UNNAMED_10_DS90LV001_I68_EN: R191.1(A<0>) U40.8(EN)
UNNAMED_10_DS90LV001_I85_EN: R192.1(A<0>) U41.8(EN)
UNNAMED_10_DS90LV001_I90_EN: R195.1(A<0>) U42.8(EN)
UNNAMED_10_DS90LV001_I90_OUT: R183.1(A<0>) U42.6(OUT+)
UNNAMED_10_DS90LV001_I90_OUT_1: R181.2(B<0>) U42.7(OUT-)
UNNAMED_10_DS90LV001_I94_EN: R196.1(A<0>) U43.8(EN)
UNNAMED_10_DS90LV001_I94_OUT: R186.1(A<0>) U43.6(OUT+)
UNNAMED_10_DS90LV001_I94_OUT_1: R184.2(B<0>) U43.7(OUT-)
USD_LED: DS6.2(K1) R145.1(A<0>) U32.10(P5)
VETO_LA_N: PL10.D3(PAIR13_B) SK4.8LA
VETO_LA_P: PL10.C3(PAIR13_A) SK4.7LA
VETO_LB_N: PL10.D5(PAIR15_B) SK4.8LB
VETO_LB_P: PL10.C5(PAIR15_A) SK4.7LB
VETO_LC_N: PL10.D7(PAIR17_B) SK4.8LC
VETO_LC_P: PL10.C7(PAIR17_A) SK4.7LC
VETO_LD_N: PL10.D9(PAIR19_B) SK4.8LD
VETO_LD_P: PL10.C9(PAIR19_A) SK4.7LD
VETO_LE_N: PL9.D4(PAIR14_B) SK4.8LE
VETO_LE_P: PL9.C4(PAIR14_A) SK4.7LE
VETO_LF_N: PL9.D6(PAIR16_B) SK4.8LF
VETO_LF_P: PL9.C6(PAIR16_A) SK4.7LF
VETO_LG_N: PL9.D8(PAIR18_B) SK4.8LG
VETO_LG_P: PL9.C8(PAIR18_A) SK4.7LG
VETO_LH_N: PL9.D10(PAIR20_B) SK4.8LH
VETO_LH_P: PL9.C10(PAIR20_A) SK4.7LH
VETO_UA_N: PL10.D4(PAIR14_B) SK4.8UA
VETO_UA_P: PL10.C4(PAIR14_A) SK4.7UA
VETO_UB_N: PL10.D6(PAIR16_B) SK4.8UB
VETO_UB_P: PL10.C6(PAIR16_A) SK4.7UB
VETO_UC_N: PL10.D8(PAIR18_B) SK4.8UC
VETO_UC_P: PL10.C8(PAIR18_A) SK4.7UC
VETO_UD_N: PL10.D10(PAIR20_B) SK4.8UD
VETO_UD_P: PL10.C10(PAIR20_A) SK4.7UD
VETO_UE_N: PL9.D5(PAIR15_B) SK4.8UE
VETO_UE_P: PL9.C5(PAIR15_A) SK4.7UE
VETO_UF_N: PL9.D7(PAIR17_B) SK4.8UF
VETO_UF_P: PL9.C7(PAIR17_A) SK4.7UF
VETO_UG_N: PL9.D9(PAIR19_B) SK4.8UG
VETO_UG_P: PL9.C9(PAIR19_A) SK4.7UG
VETO_UH_N: PL9.F10(PAIR30_B) SK4.8UH
VETO_UH_P: PL9.E10(PAIR30_A) SK4.7UH
WP: R147.1(A<0>) U32.12(P7) U34.7(WP)

Pads without a net: PL8 A B C; PL9 A5 A6 A7 A8 B5 B6 B7 B8 F1 F2; PL10 D2; U1 1; U2 4; U3 21; U4 3 4 6; U5 3; U6 3 4 6; U7 4; U8 2 3 6 7; U9 4; U11 1; U12 7 8 9 12 13 14 21; U13 4; U14 2 7 8 13; U16 14; U17 7 8 9 12 13 14 21; U18 4; U19 4; U20 4; U21 4; U22 4; U23 4; U24 4; U25 4; U26 4; U27 4; U28 4; U29 4; U30 1; U31 1; U32 13; U33 A17 B23; U36 4; U37 4; U38 4; U39 4; U40 4; U41 4; U42 4; U43 4; U44 4; U45 4; U46 4; U47 4; U48 4; U49 4; U50 4; U51 4; U52 4; U53 4; U54 4; U55 4; U56 4; U57 4; U58 4; U59 22; U60 22; UXX 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16; UXX#2 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16

## Via types
v1: diameter 0.66, hole 0.305, TOP to BOTTOM, 340 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3V3: length 137.1
  TOP w0.5: U24.5 v1(64.97,111.75) 64.97,110.85 C57.2 ; C58.2 64.97,132.25 v1(64.97,133.15) U7.5 ; R125.2 v1(62.3,107.45) R129.2 ; R196.2 v1(62.3,56.65) R192.2 ; R130.2 v1(62.3,128.85) R126.2 ; C70.2 64.97,121.55 v1(64.97,122.45) U27.5 ; U40.5 v1(64.97,28.85) 64.97,27.95 C114.2 ; C171.2 82.57,94.85 v1(82.57,95.75) U55.5 ; R249.2 v1(79.9,112.85) R245.2 ; R112.2 v1(62.3,118.15) R110.2 ; R195.2 v1(62.3,35.25) R191.2 ; R99.2 v1(42,23.35) R95.2 ; C115.2 64.97,49.35 v1(64.97,50.25) U41.5 ; 44.67,6.25 v1(44.67,5.45) 44.67,4.55 44.76,4.45 ; 64.97,61.75 v1(64.97,60.95) 64.97,60.05 C101.2 ; 64.97,40.34 v1(64.97,39.55) 64.97,38.65 C99.2 ; R268.2 v1(79.9,123.55) R264.2 ; R246.2 v1(79.9,134.25) R250.2 ; R174.2 v1(62.3,67.35) R178.2 ; 44.76,15.95 44.67,16.05 v1(44.67,16.95) 44.67,17.75 ; R214.2 v1(79.9,72.65) R210.2 ; C138.2 82.57,33.25 v1(82.57,34.15) U48.5 ; R173.2 v1(62.3,45.95) R177.2 ; U49.5 v1(82.57,55.55) 82.57,54.65 C134.2 ; C156.2 82.57,126.95 v1(82.57,127.85) U2.5 ; R39.2 v1(62.3,139.55) R35.2 ; C170.2 82.57,116.25 v1(82.57,117.15) U56.5 ; R213.2 v1(79.9,51.25) R209.2 ; R263.2 v1(79.9,102.15) R267.2 ; R227.2 v1(79.9,40.55) R231.2 ; R232.2 v1(79.9,61.95) R228.2 ; 43.03,11.85 R94.2 v1(42,11.85) R98.2 40.97,11.85 ; U26.5 v1(64.97,101.05) 64.97,100.15 C67.2 ; U45.5 v1(82.57,66.25) 82.57,65.35 C128.2 ; U52.5 v1(82.57,106.45) 82.57,105.55 C157.2 ; U44.5 v1(82.57,44.85) 82.57,43.95 C121.2
  BOTTOM w0.5: C108.2 59.63,27.95 v1(59.63,28.85) U42.5 ; R187.2 v1(57.97,35.51) ; 59.63,40.34 v1(59.63,39.55) 59.63,38.65 C95.2 ; U57.5 v1(77.23,95.75) 77.23,94.85 C166.2 ; U46.5 v1(77.23,44.85) 77.23,43.95 C124.2 ; C151.2 77.23,126.95 v1(77.23,127.85) U54.5 ; C54.2 59.63,110.85 v1(59.63,111.75) U25.5 ; R166.2 v1(57.97,46.21) ; R228.2 v1(79.9,61.95) ; R174.2 v1(62.3,67.35) ; 39.33,17.75 v1(39.33,16.95) 39.33,16.05 39.24,15.95 ; R123.2 v1(57.97,129.11) ; U28.5 v1(59.63,101.05) 59.63,100.15 C63.2 ; R108.2 v1(57.97,118.41) ; C136.2 77.23,54.65 v1(77.23,55.55) U51.5 ; R35.2 v1(62.3,139.55) ; 39.33,6.25 v1(39.33,5.45) 39.33,4.55 39.24,4.45 ; C123.2 77.23,65.35 v1(77.23,66.25) U47.5 ; R263.2 v1(79.9,102.15) ; C96.2 59.63,60.05 v1(59.63,60.95) 59.63,61.75 ; R171.2 v1(57.97,67.61) ; R225.2 v1(75.56,62.21) ; R27.2 v1(57.97,139.81) ; R210.2 v1(79.9,72.65) ; C143.2 77.23,33.25 v1(77.23,34.15) U50.5 ; R223.2 v1(75.56,40.81) ; v1(37.66,12.11) 37.66,11.15 ; C152.2 77.23,105.55 v1(77.23,106.45) U53.5 ; R238.2 v1(75.56,113.11) ; R246.2 v1(79.9,134.25) ; U29.5 v1(59.63,122.45) 59.63,121.55 C64.2 ; R192.2 v1(62.3,56.65) ; R202.2 v1(75.56,51.51) ; R173.2 v1(62.3,45.95) ; C109.2 59.63,49.35 v1(59.63,50.25) U43.5 ; U58.5 v1(77.23,117.15) 77.23,116.25 C164.2 ; R189.2 v1(57.97,56.91) ; 37.66,22.65 v1(37.66,23.61) ; R264.2 v1(79.9,123.55) ; R121.2 v1(57.97,107.71) ; C55.2 59.63,132.25 v1(59.63,133.15) U9.5 ; R207.2 v1(75.56,72.91) ; R125.2 v1(62.3,107.45) ; R243.2 v1(75.56,134.51) ; R261.2 v1(75.56,123.81) ; R227.2 v1(79.9,40.55) ; R259.2 v1(75.56,102.41) ; R209.2 v1(79.9,51.25) ; R126.2 v1(62.3,128.85) ; R191.2 v1(62.3,35.25) ; R245.2 v1(79.9,112.85) ; R110.2 v1(62.3,118.15)
GND: length 147.4
  TOP w0.5: U19.1 v1(40.5,21.55) ; v1(42,4.45) C40.1 43.03,4.45 ; v1(62.3,59.95) C101.1 ; 77.23,100.35 v1(78.39,100.35) ; v1(79.9,116.15) C170.1 ; U49.1 v1(78.39,60.16) ; v1(79.9,105.45) C157.1 ; U56.1 v1(78.39,121.75) ; U24.1 v1(60.8,116.36) ; v1(79.9,54.55) C134.1 ; U44.1 v1(78.39,49.45) ; v1(79.9,126.85) C156.1 ; U2.1 v1(78.39,132.45) ; v1(62.3,38.55) C99.1 ; U18.1 v1(40.5,10.05) ; v1(62.3,100.05) C67.1 ; v1(62.3,132.15) C58.1 ; U48.1 v1(78.39,38.76) ; U41.1 v1(60.8,54.86) ; v1(79.9,43.85) C121.1 ; v1(62.3,121.45) C70.1 ; v1(42,15.95) C42.1 ; v1(79.9,33.15) C138.1 ; U36.1 v1(60.8,44.16) ; U7.1 v1(60.8,137.75) ; v1(62.3,49.25) C115.1 ; U27.1 v1(60.8,127.06) ; 77.23,70.85 v1(78.39,70.85) ; v1(79.9,65.25) C128.1 ; U52.1 v1(78.39,111.06) ; U37.1 v1(60.8,65.56) ; v1(62.3,27.85) C114.1 ; U26.1 v1(60.8,105.66) ; v1(62.3,110.75) C57.1 ; v1(79.9,94.75) C171.1 ; U40.1 v1(60.8,33.45)
  BOTTOM w0.5: v1(42,4.45) C41.1 40.97,4.45 ; C93.1 v1(66,67.35) ; 82.57,70.85 v1(81.41,70.85) ; C168.1 v1(73.97,98.45) C165.1 ; C166.1 v1(79.9,94.75) ; C107.1 v1(66,56.65) ; R167.1 v1(57.97,38.28) ; C106.1 v1(66,35.25) ; C68.1 v1(56.36,103.75) C65.1 ; U53.1 v1(81.41,111.06) ; U50.1 v1(81.41,38.76) ; C139.1 v1(73.97,58.25) C141.1 ; C126.1 v1(73.97,47.55) C122.1 ; R260.1 v1(75.56,94.48) ; R172.1 v1(57.97,59.69) ; R224.1 v1(75.56,32.88) ; C152.1 v1(79.9,105.45) ; C54.1 v1(62.3,110.75) ; 37.66,5.15 v1(37.66,4.19) ; C92.1 v1(66,45.95) ; C95.1 v1(62.3,38.55) ; C32.1 v1(36.06,8.15) C34.1 ; C140.1 v1(73.97,36.85) C137.1 ; C149.1 v1(83.6,112.85) ; R124.1 v1(57.97,121.19) ; C66.1 v1(56.36,125.15) C69.1 ; C100.1 v1(56.36,63.65) C97.1 ; C19.1 v1(56.36,135.85) C18.1 ; C162.1 v1(83.6,123.55) ; C112.1 v1(56.36,31.55) C110.1 ; U42.1 v1(63.81,33.45) ; U20.1 v1(43.5,10.05) ; v1(83.6,61.95) C142.1 ; R226.1 v1(75.56,54.28) ; C98.1 v1(56.36,42.25) C94.1 ; U9.1 v1(63.81,137.75) ; C55.1 v1(62.3,132.15) ; C56.1 v1(56.36,114.45) C53.1 ; C169.1 v1(73.97,119.85) C167.1 ; C164.1 v1(79.9,116.15) ; C123.1 v1(79.9,65.25) ; U58.1 v1(81.41,121.75) ; C127.1 v1(73.97,68.95) C125.1 ; C136.1 v1(79.9,54.55) ; v1(83.6,51.25) C129.1 ; U51.1 v1(81.41,60.16) ; C151.1 v1(79.9,126.85) ; R244.1 v1(75.56,126.58) ; C111.1 v1(56.36,52.95) C113.1 ; U25.1 v1(63.81,116.36) ; U39.1 v1(63.81,65.56) ; U38.1 v1(63.81,44.16) ; U28.1 v1(63.81,105.66) ; C148.1 v1(83.6,134.25) ; U46.1 v1(81.41,49.45) ; C64.1 v1(62.3,121.45) ; C150.1 v1(73.97,109.15) C154.1 ; v1(83.6,40.55) C135.1 ; R262.1 v1(75.56,115.89) ; C108.1 v1(62.3,27.85) ; C120.1 v1(83.6,72.65) ; R109.1 v1(57.97,110.48) ; R208.1 v1(75.56,64.98) ; U21.1 v1(43.5,21.55) ; C155.1 v1(73.97,130.55) C153.1 ; R188.1 v1(57.97,27.59) ; C163.1 v1(83.6,102.15) ; C43.1 v1(42,15.95) ; U29.1 v1(63.81,127.06) ; C62.1 v1(66,128.85) ; R203.1 v1(75.56,43.59) ; U54.1 v1(81.41,132.45) ; C63.1 v1(62.3,100.05) ; R28.1 v1(57.97,131.88) ; R190.1 v1(57.97,48.98) ; C143.1 v1(79.9,33.15) ; C96.1 v1(62.3,59.95) ; C33.1 v1(36.06,19.65) C35.1 ; 37.66,16.65 v1(37.66,15.68) ; R122.1 v1(57.97,99.78) ; C51.1 v1(66,118.15) ; U43.1 v1(63.81,54.86) ; C124.1 v1(79.9,43.85) ; C52.1 v1(66,139.55) ; 82.57,100.35 v1(81.41,100.35) ; C61.1 v1(66,107.45) ; R239.1 v1(75.56,105.19) ; C109.1 v1(62.3,49.25)
FPGA_SPARE_IN1_I_N: length 3
  TOP w0.15: 34.34,9.15 v1(33.4,9.15) 32.44,9.15 R82.2
  BOTTOM w0.15: 34.34,9.15 v1(33.4,9.15)
FPGA_SPARE_IN1_I_P: length 3
  TOP w0.15: 34.34,7.15 v1(33.4,7.15) 32.44,7.15 R82.1
  BOTTOM w0.15: 34.34,7.15 v1(33.4,7.15)
FPGA_SPARE_IN1_N: length 3.3
  TOP w0.15: U18.7 v1(45.76,8.79) 46.57,8.79 R96.2
  BOTTOM w0.15: U18.7 v1(45.76,8.79)
FPGA_SPARE_IN1_P: length 3.3
  TOP w0.15: R96.1 46.57,7.52 v1(45.76,7.52) U18.6
  BOTTOM w0.15: U18.6 v1(45.76,7.52)
FPGA_SPARE_IN2_I_N: length 3
  TOP w0.15: 34.34,20.65 v1(33.4,20.65) 32.44,20.65 R83.2
  BOTTOM w0.15: 34.34,20.65 v1(33.4,20.65)
FPGA_SPARE_IN2_I_P: length 3
  TOP w0.15: R83.1 32.44,18.65 v1(33.4,18.65) 34.34,18.65
  BOTTOM w0.15: 34.34,18.65 v1(33.4,18.65)
FPGA_SPARE_IN2_N: length 3.3
  TOP w0.15: U19.7 v1(45.76,20.29) 46.57,20.29 R97.2
  BOTTOM w0.15: U19.7 v1(45.76,20.29)
FPGA_SPARE_IN2_P: length 3.3
  TOP w0.15: U19.6 v1(45.76,19.02) 46.57,19.02 R97.1
  BOTTOM w0.15: U19.6 v1(45.76,19.02)
STATUS_LA_N: length 3
  TOP w0.15: R20.2 52.74,136.85 v1(53.7,136.85) C22.1
  BOTTOM w0.15: C22.1 v1(53.7,136.85)
STATUS_LA_P: length 3
  TOP w0.15: C23.1 v1(53.7,134.85) 52.74,134.85 R20.1
  BOTTOM w0.15: C23.1 v1(53.7,134.85)
STATUS_LB_N: length 3
  TOP w0.15: C73.1 v1(53.7,126.15) 52.74,126.15 R114.2
  BOTTOM w0.15: C73.1 v1(53.7,126.15)
STATUS_LB_P: length 3
  TOP w0.15: C74.1 v1(53.7,124.15) 52.74,124.15 R114.1
  BOTTOM w0.15: C74.1 v1(53.7,124.15)
STATUS_LC_N: length 3
  TOP w0.15: R104.2 52.74,115.45 v1(53.7,115.45) C59.1
  BOTTOM w0.15: C59.1 v1(53.7,115.45)
STATUS_LC_P: length 3
  TOP w0.15: C60.1 v1(53.7,113.45) 52.74,113.45 R104.1
  BOTTOM w0.15: C60.1 v1(53.7,113.45)
STATUS_LD_N: length 3
  TOP w0.15: C71.1 v1(53.7,104.75) 52.74,104.75 R113.2
  BOTTOM w0.15: C71.1 v1(53.7,104.75)
STATUS_LD_P: length 3
  TOP w0.15: R113.1 52.74,102.75 v1(53.7,102.75) C72.1
  BOTTOM w0.15: C72.1 v1(53.7,102.75)
STATUS_LE_N: length 3
  TOP w0.15: R162.2 52.74,64.65 v1(53.7,64.65) C104.1
  BOTTOM w0.15: C104.1 v1(53.7,64.65)
STATUS_LE_P: length 3
  TOP w0.15: C105.1 v1(53.7,62.65) 52.74,62.65 R162.1
  BOTTOM w0.15: C105.1 v1(53.7,62.65)
STATUS_LF_N: length 3
  TOP w0.15: C118.1 v1(53.7,53.95) 52.74,53.95 R180.2
  BOTTOM w0.15: C118.1 v1(53.7,53.95)
STATUS_LF_P: length 3
  TOP w0.15: 52.6,52.09 52.74,51.95 v1(53.7,51.95) C119.1
  BOTTOM w0.15: C119.1 v1(53.7,51.95)
STATUS_LG_N: length 3
  TOP w0.15: C102.1 v1(53.7,43.25) 52.74,43.25 R161.2
  BOTTOM w0.15: C102.1 v1(53.7,43.25)
STATUS_LG_P: length 3
  TOP w0.15: C103.1 v1(53.7,41.25) 52.74,41.25 R161.1
  BOTTOM w0.15: C103.1 v1(53.7,41.25)
STATUS_LH_N: length 3
  TOP w0.15: C116.1 v1(53.7,32.55) 52.74,32.55 R179.2
  BOTTOM w0.15: C116.1 v1(53.7,32.55)
STATUS_LH_P: length 3
  TOP w0.15: R179.1 52.74,30.55 v1(53.7,30.55) C117.1
  BOTTOM w0.15: C117.1 v1(53.7,30.55)
STATUS_OUT_LA_N: length 3.3
  TOP w0.15: U7.7 v1(66.06,136.49) 66.87,136.49 R37.2
  BOTTOM w0.15: U7.7 v1(66.06,136.49)
STATUS_OUT_LA_P: length 3.3
  TOP w0.15: U7.6 v1(66.06,135.22) 66.87,135.22 R37.1
  BOTTOM w0.15: U7.6 v1(66.06,135.22)
STATUS_OUT_LB_N: length 3.3
  TOP w0.15: U27.7 v1(66.06,125.78) 66.87,125.78 R128.2
  BOTTOM w0.15: U27.7 v1(66.06,125.78)
STATUS_OUT_LB_P: length 3.3
  TOP w0.15: U27.6 v1(66.06,124.52) 66.87,124.52 R128.1
  BOTTOM w0.15: U27.6 v1(66.06,124.52)
STATUS_OUT_LC_N: length 3.3
  TOP w0.15: U24.7 v1(66.06,115.08) 66.87,115.08 R111.2
  BOTTOM w0.15: U24.7 v1(66.06,115.08)
STATUS_OUT_LC_P: length 3.3
  TOP w0.15: R111.1 66.87,113.81 v1(66.06,113.81) U24.6
  BOTTOM w0.15: U24.6 v1(66.06,113.81)
STATUS_OUT_LD_N: length 3.3
  TOP w0.15: U26.7 v1(66.06,104.39) 66.87,104.39 R127.2
  BOTTOM w0.15: U26.7 v1(66.06,104.39)
STATUS_OUT_LD_P: length 3.3
  TOP w0.15: R127.1 66.87,103.11 v1(66.06,103.11) U26.6
  BOTTOM w0.15: U26.6 v1(66.06,103.11)
STATUS_OUT_LE_N: length 3.3
  TOP w0.15: U37.7 v1(66.06,64.28) 66.87,64.28 R176.2
  BOTTOM w0.15: U37.7 v1(66.06,64.28)
STATUS_OUT_LE_P: length 3.3
  TOP w0.15: R176.1 66.87,63.02 v1(66.06,63.02) U37.6
  BOTTOM w0.15: U37.6 v1(66.06,63.02)
STATUS_OUT_LF_N: length 3.3
  TOP w0.15: U41.7 v1(66.06,53.59) 66.87,53.59 R194.2
  BOTTOM w0.15: U41.7 v1(66.06,53.59)
STATUS_OUT_LF_P: length 3.3
  TOP w0.15: 67.1,52.09 66.87,52.31 v1(66.06,52.31) U41.6
  BOTTOM w0.15: U41.6 v1(66.06,52.31)
STATUS_OUT_LG_N: length 3.3
  TOP w0.15: R175.2 66.87,42.88 v1(66.06,42.88) U36.7
  BOTTOM w0.15: U36.7 v1(66.06,42.88)
STATUS_OUT_LG_P: length 3.3
  TOP w0.15: U36.6 v1(66.06,41.62) 66.87,41.62 R175.1
  BOTTOM w0.15: U36.6 v1(66.06,41.62)
STATUS_OUT_LH_N: length 3.3
  TOP w0.15: U40.7 v1(66.06,32.19) 66.87,32.19 R193.2
  BOTTOM w0.15: U40.7 v1(66.06,32.19)
STATUS_OUT_LH_P: length 3.3
  TOP w0.15: U40.6 v1(66.06,30.91) 66.87,30.91 R193.1
  BOTTOM w0.15: U40.6 v1(66.06,30.91)
STATUS_OUT_UA_N: length 3.3
  TOP w0.15: U2.7 v1(83.67,131.19) 84.47,131.19 R248.2
  BOTTOM w0.15: U2.7 v1(83.67,131.19)
STATUS_OUT_UA_P: length 3.3
  TOP w0.15: U2.6 v1(83.67,129.92) 84.47,129.92 R248.1
  BOTTOM w0.15: U2.6 v1(83.67,129.92)
STATUS_OUT_UB_N: length 3.3
  TOP w0.15: R266.2 84.47,120.48 v1(83.67,120.48) U56.7
  BOTTOM w0.15: U56.7 v1(83.67,120.48)
STATUS_OUT_UB_P: length 3.3
  TOP w0.15: U56.6 v1(83.67,119.22) 84.47,119.22 R266.1
  BOTTOM w0.15: U56.6 v1(83.67,119.22)
STATUS_OUT_UC_N: length 3.3
  TOP w0.15: R247.2 84.47,109.78 v1(83.67,109.78) U52.7
  BOTTOM w0.15: U52.7 v1(83.67,109.78)
STATUS_OUT_UC_P: length 3.3
  TOP w0.15: R247.1 84.47,108.52 v1(83.67,108.52) U52.6
  BOTTOM w0.15: U52.6 v1(83.67,108.52)
STATUS_OUT_UD_N: length 3.3
  TOP w0.15: 84.7,99.31 84.47,99.09 v1(83.67,99.09) U55.7
  BOTTOM w0.15: U55.7 v1(83.67,99.09)
STATUS_OUT_UD_P: length 3.3
  TOP w0.15: R265.1 84.47,97.81 v1(83.67,97.81) 82.57,97.81
  BOTTOM w0.15: 82.57,97.81 v1(83.67,97.81)
STATUS_OUT_UE_N: length 3.3
  TOP w0.15: U45.7 v1(83.67,69.59) 84.47,69.59 84.7,69.81
  BOTTOM w0.15: U45.7 v1(83.67,69.59)
STATUS_OUT_UE_P: length 3.3
  TOP w0.15: R212.1 84.47,68.31 v1(83.67,68.31) U45.6
  BOTTOM w0.15: U45.6 v1(83.67,68.31)
STATUS_OUT_UF_N: length 3.3
  TOP w0.15: U49.7 v1(83.67,58.89) 84.47,58.89 R230.2
  BOTTOM w0.15: U49.7 v1(83.67,58.89)
STATUS_OUT_UF_P: length 3.3
  TOP w0.15: R230.1 84.47,57.61 v1(83.67,57.61) U49.6
  BOTTOM w0.15: U49.6 v1(83.67,57.61)
STATUS_OUT_UG_N: length 3.3
  TOP w0.15: U44.7 v1(83.67,48.19) 84.47,48.19 84.7,48.41
  BOTTOM w0.15: U44.7 v1(83.67,48.19)
STATUS_OUT_UG_P: length 3.3
  TOP w0.15: R211.1 84.47,46.91 v1(83.67,46.91) 82.57,46.91
  BOTTOM w0.15: 82.57,46.91 v1(83.67,46.91)
STATUS_OUT_UH_N: length 3.3
  TOP w0.15: U48.7 v1(83.67,37.48) 84.47,37.48 R229.2
  BOTTOM w0.15: U48.7 v1(83.67,37.48)
STATUS_OUT_UH_P: length 3.3
  TOP w0.15: R229.1 84.47,36.22 v1(83.67,36.22) U48.6
  BOTTOM w0.15: U48.6 v1(83.67,36.22)
STATUS_UA_N: length 3
  TOP w0.15: C160.1 v1(71.3,131.55) 70.33,131.55 R234.2
  BOTTOM w0.15: C160.1 v1(71.3,131.55)
STATUS_UA_P: length 3
  TOP w0.15: C161.1 v1(71.3,129.55) 70.33,129.55 R234.1
  BOTTOM w0.15: C161.1 v1(71.3,129.55)
STATUS_UB_N: length 3
  TOP w0.15: C174.1 v1(71.3,120.85) 70.33,120.85 R252.2
  BOTTOM w0.15: C174.1 v1(71.3,120.85)
STATUS_UB_P: length 3
  TOP w0.15: R252.1 70.33,118.85 v1(71.3,118.85) C175.1
  BOTTOM w0.15: C175.1 v1(71.3,118.85)
STATUS_UC_N: length 3
  TOP w0.15: C158.1 v1(71.3,110.15) 70.33,110.15 R233.2
  BOTTOM w0.15: C158.1 v1(71.3,110.15)
STATUS_UC_P: length 3
  TOP w0.15: C159.1 v1(71.3,108.15) 70.33,108.15 R233.1
  BOTTOM w0.15: C159.1 v1(71.3,108.15)
STATUS_UD_N: length 3
  TOP w0.15: 70.2,99.31 70.33,99.45 v1(71.3,99.45) C172.1
  BOTTOM w0.15: C172.1 v1(71.3,99.45)
STATUS_UD_P: length 3
  TOP w0.15: C173.1 v1(71.3,97.45) 70.33,97.45 R251.1
  BOTTOM w0.15: C173.1 v1(71.3,97.45)
STATUS_UE_N: length 3
  TOP w0.15: 70.2,69.81 70.33,69.95 v1(71.3,69.95) C132.1
  BOTTOM w0.15: C132.1 v1(71.3,69.95)
STATUS_UE_P: length 3
  TOP w0.15: C133.1 v1(71.3,67.95) 70.33,67.95 R198.1
  BOTTOM w0.15: C133.1 v1(71.3,67.95)
STATUS_UF_N: length 3
  TOP w0.15: R216.2 70.33,59.25 v1(71.3,59.25) C146.1
  BOTTOM w0.15: C146.1 v1(71.3,59.25)
STATUS_UF_P: length 3
  TOP w0.15: R216.1 70.33,57.25 v1(71.3,57.25) C147.1
  BOTTOM w0.15: C147.1 v1(71.3,57.25)
STATUS_UG_N: length 3
  TOP w0.15: C130.1 v1(71.3,48.55) 70.33,48.55 70.2,48.41
  BOTTOM w0.15: C130.1 v1(71.3,48.55)
STATUS_UG_P: length 3
  TOP w0.15: C131.1 v1(71.3,46.55) 70.33,46.55 R197.1
  BOTTOM w0.15: C131.1 v1(71.3,46.55)
STATUS_UH_N: length 3
  TOP w0.15: R215.2 70.33,37.85 v1(71.3,37.85) C144.1
  BOTTOM w0.15: C144.1 v1(71.3,37.85)
STATUS_UH_P: length 3
  TOP w0.15: C145.1 v1(71.3,35.85) 70.33,35.85 R215.1
  BOTTOM w0.15: C145.1 v1(71.3,35.85)
UNNAMED_1_CAPACITOR_I90_B: length 6.5
  TOP w0.15: R84.1 v1(35.94,10.15) 35.94,9.28 C36.2 37.47,9.15 R85.2 37.83,8.79 U18.2
  BOTTOM w0.15: R84.1 v1(35.94,10.15)
UNNAMED_1_CAPACITOR_I99_B: length 6.5
  TOP w0.15: U18.3 37.83,7.52 R85.1 37.47,7.15 C37.2 35.94,7.02 v1(35.94,6.15) R86.2
  BOTTOM w0.15: R86.2 v1(35.94,6.15)
UNNAMED_1_CAPACITOR_I100_B: length 6.5
  TOP w0.15: U19.2 37.83,20.29 R88.2 37.47,20.65 C38.2 35.94,20.78 v1(35.94,21.65) R87.1
  BOTTOM w0.15: R87.1 v1(35.94,21.65)
UNNAMED_1_CAPACITOR_I101_B: length 6.5
  TOP w0.15: R89.2 v1(35.94,17.65) 35.94,18.52 C39.2 37.47,18.65 R88.1 37.83,19.02 U19.3
  BOTTOM w0.15: R89.2 v1(35.94,17.65)
UNNAMED_1_DS90LV001_I78_EN: length 1.8
  TOP w0.15: U18.8 44.67,11.05 44.76,11.15 44.76,11.85
UNNAMED_1_DS90LV001_I79_EN: length 1.8
  TOP w0.15: 39.24,11.85 v1(39.24,10.89)
  BOTTOM w0.15: v1(39.24,10.89) 39.24,10.15 U20.8
UNNAMED_1_DS90LV001_I79_OUT: length 3.2
  TOP w0.15: v1(38,6.15) 38,5.48 37.66,5.15
  BOTTOM w0.15: v1(38,6.15) 38.38,6.53 38.38,6.88 39.02,7.52 U20.6
UNNAMED_1_DS90LV001_I79_OUT_1: length 3.2
  TOP w0.15: 37.66,11.15 38,10.82 v1(38,10.15)
  BOTTOM w0.15: U20.7 39.02,8.79 38.38,9.42 38.38,9.77 v1(38,10.15)
UNNAMED_1_DS90LV001_I80_EN: length 1.8
  TOP w0.15: 39.24,23.35 v1(39.24,22.38)
  BOTTOM w0.15: v1(39.24,22.38) 39.24,21.65 U21.8
UNNAMED_1_DS90LV001_I80_OUT: length 3.2
  TOP w0.15: 37.66,16.65 38,16.98 v1(38,17.65)
  BOTTOM w0.15: v1(38,17.65) 38.38,18.03 38.38,18.38 39.02,19.02 U21.6
UNNAMED_1_DS90LV001_I80_OUT_1: length 3.2
  TOP w0.15: v1(38,21.65) 38,22.31 37.66,22.65
  BOTTOM w0.15: U21.7 39.02,20.29 38.38,20.92 38.38,21.27 v1(38,21.65)
UNNAMED_1_DS90LV001_I81_EN: length 1.8
  TOP w0.15: 44.76,23.35 44.76,22.65 44.67,22.55 U19.8
UNNAMED_2_CAPACITOR_I8_B: length 6.5
  TOP w0.15: U7.2 58.13,136.49 R25.2 57.77,136.85 C22.2 56.23,136.98 v1(56.23,137.85) R24.1
  BOTTOM w0.15: R24.1 v1(56.23,137.85)
UNNAMED_2_CAPACITOR_I25_B: length 6.5
  TOP w0.15: R26.2 v1(56.23,133.85) 56.23,134.72 C23.2 57.77,134.85 R25.1 58.13,135.22 U7.3
  BOTTOM w0.15: R26.2 v1(56.23,133.85)
UNNAMED_2_CAPACITOR_I157_B: length 6.5
  TOP w0.15: R118.1 v1(56.23,127.15) 56.23,126.28 C73.2 57.77,126.15 R119.2 58.13,125.78 U27.2
  BOTTOM w0.15: R118.1 v1(56.23,127.15)
UNNAMED_2_CAPACITOR_I170_B: length 6.5
  TOP w0.15: R120.2 v1(56.23,123.15) 56.23,124.02 C74.2 57.77,124.15 R119.1 58.13,124.52 U27.3
  BOTTOM w0.15: R120.2 v1(56.23,123.15)
UNNAMED_2_CAPACITOR_I189_B: length 6.5
  TOP w0.15: R105.1 v1(56.23,116.45) 56.23,115.58 C59.2 57.77,115.45 R106.2 58.13,115.08 U24.2
  BOTTOM w0.15: R105.1 v1(56.23,116.45)
UNNAMED_2_CAPACITOR_I190_B: length 6.5
  TOP w0.15: R107.2 v1(56.23,112.45) 56.23,113.32 C60.2 57.77,113.45 R106.1 58.13,113.81 U24.3
  BOTTOM w0.15: R107.2 v1(56.23,112.45)
UNNAMED_2_CAPACITOR_I209_B: length 6.5
  TOP w0.15: R115.1 v1(56.23,105.75) 56.23,104.88 C71.2 57.77,104.75 R116.2 58.13,104.39 U26.2
  BOTTOM w0.15: R115.1 v1(56.23,105.75)
UNNAMED_2_CAPACITOR_I210_B: length 6.5
  TOP w0.15: U26.3 58.13,103.11 R116.1 57.77,102.75 C72.2 56.23,102.62 v1(56.23,101.75) R117.2
  BOTTOM w0.15: R117.2 v1(56.23,101.75)
UNNAMED_2_DS90LV001_I18_EN: length 1.8
  TOP w0.15: R35.1 65.06,138.85 64.97,138.75 U7.8
UNNAMED_2_DS90LV001_I19_EN: length 1.8
  TOP w0.15: R39.1 v1(59.53,138.58)
  BOTTOM w0.15: U9.8 59.53,137.85 v1(59.53,138.58)
UNNAMED_2_DS90LV001_I19_OUT: length 3.2
  TOP w0.15: R24.2 58.3,138.51 v1(58.3,137.85)
  BOTTOM w0.15: U9.7 59.32,136.49 58.68,137.12 58.68,137.47 v1(58.3,137.85)
UNNAMED_2_DS90LV001_I19_OUT_1: length 3.2
  TOP w0.15: v1(58.3,133.85) 58.3,133.19 R26.1
  BOTTOM w0.15: U9.6 59.32,135.22 58.68,134.58 58.68,134.23 v1(58.3,133.85)
UNNAMED_2_DS90LV001_I162_EN: length 1.8
  TOP w0.15: R130.1 v1(59.53,127.89)
  BOTTOM w0.15: U29.8 59.53,127.15 v1(59.53,127.89)
UNNAMED_2_DS90LV001_I162_OUT: length 3.2
  TOP w0.15: v1(58.3,127.15) 58.3,127.81 R118.2
  BOTTOM w0.15: U29.7 59.32,125.78 58.68,126.42 58.68,126.77 v1(58.3,127.15)
UNNAMED_2_DS90LV001_I162_OUT_1: length 3.2
  TOP w0.15: R120.1 58.3,122.48 v1(58.3,123.15)
  BOTTOM w0.15: v1(58.3,123.15) 58.68,123.53 58.68,123.88 59.32,124.52 U29.6
UNNAMED_2_DS90LV001_I166_EN: length 1.8
  TOP w0.15: R126.1 65.06,128.15 64.97,128.05 U27.8
UNNAMED_2_DS90LV001_I181_EN: length 1.8
  TOP w0.15: R112.1 v1(59.53,117.19)
  BOTTOM w0.15: v1(59.53,117.19) 59.53,116.45 U25.8
UNNAMED_2_DS90LV001_I181_OUT: length 3.2
  TOP w0.15: v1(58.3,112.45) 58.3,111.78 R107.1
  BOTTOM w0.15: U25.6 59.32,113.81 58.68,113.18 58.68,112.83 v1(58.3,112.45)
UNNAMED_2_DS90LV001_I181_OUT_1: length 3.2
  TOP w0.15: R105.2 58.3,117.11 v1(58.3,116.45)
  BOTTOM w0.15: U25.7 59.32,115.08 58.68,115.72 58.68,116.07 v1(58.3,116.45)
UNNAMED_2_DS90LV001_I185_EN: length 1.8
  TOP w0.15: R110.1 65.06,117.45 64.97,117.35 U24.8
