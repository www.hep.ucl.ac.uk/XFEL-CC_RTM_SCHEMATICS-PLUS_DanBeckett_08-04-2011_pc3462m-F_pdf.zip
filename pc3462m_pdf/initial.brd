# Allegro board initial.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UNNAMED_2_DS90LV001_I201_EN: length 1.8
  TOP w0.15: R129.1 v1(59.53,106.48)
  BOTTOM w0.15: U28.8 59.53,105.75 v1(59.53,106.48)
UNNAMED_2_DS90LV001_I201_OUT: length 3.2
  TOP w0.15: v1(58.3,105.75) 58.3,106.42 R115.2
  BOTTOM w0.15: U28.7 59.32,104.39 58.68,105.02 58.68,105.37 v1(58.3,105.75)
UNNAMED_2_DS90LV001_I201_OUT_1: length 3.2
  TOP w0.15: v1(58.3,101.75) 58.3,101.08 R117.1
  BOTTOM w0.15: U28.6 59.32,103.11 58.68,102.48 58.68,102.13 v1(58.3,101.75)
UNNAMED_2_DS90LV001_I205_EN: length 1.8
  TOP w0.15: U26.8 64.97,106.65 65.06,106.75 R125.1
UNNAMED_4_CAPACITOR_I14_B: length 6.5
  TOP w0.15: U52.3 75.73,108.52 R236.1 75.36,108.15 C159.2 73.83,108.02 v1(73.83,107.15) R237.2
  BOTTOM w0.15: R237.2 v1(73.83,107.15)
UNNAMED_4_CAPACITOR_I15_B: length 6.5
  TOP w0.15: U52.2 75.73,109.78 R236.2 75.36,110.15 C158.2 73.83,110.28 v1(73.83,111.15) R235.1
  BOTTOM w0.15: R235.1 v1(73.83,111.15)
UNNAMED_4_CAPACITOR_I30_B: length 6.5
  TOP w0.15: R242.2 v1(73.83,128.55) 73.83,129.42 C161.2 75.36,129.55 R241.1 75.73,129.92 U2.3
  BOTTOM w0.15: R242.2 v1(73.83,128.55)
UNNAMED_4_CAPACITOR_I31_B: length 6.5
  TOP w0.15: U2.2 75.73,131.19 R241.2 75.36,131.55 C160.2 73.83,131.68 v1(73.83,132.55) R240.1
  BOTTOM w0.15: R240.1 v1(73.83,132.55)
UNNAMED_4_CAPACITOR_I61_B: length 6.5
  TOP w0.15: 77.23,97.81 75.73,97.81 R254.1 75.36,97.45 C173.2 73.83,97.32 v1(73.83,96.45) R255.2
  BOTTOM w0.15: R255.2 v1(73.83,96.45)
UNNAMED_4_CAPACITOR_I62_B: length 6.5
  TOP w0.15: U55.2 75.73,99.09 75.36,99.45 C172.2 73.83,99.58 v1(73.83,100.45) R253.1
  BOTTOM w0.15: R253.1 v1(73.83,100.45)
UNNAMED_4_CAPACITOR_I79_B: length 6.5
  TOP w0.15: R258.2 v1(73.83,117.85) 73.83,118.72 C175.2 75.36,118.85 R257.1 75.73,119.22 U56.3
  BOTTOM w0.15: R258.2 v1(73.83,117.85)
UNNAMED_4_CAPACITOR_I80_B: length 6.5
  TOP w0.15: U56.2 75.73,120.48 R257.2 75.36,120.85 C174.2 73.83,120.98 v1(73.83,121.85) R256.1
  BOTTOM w0.15: R256.1 v1(73.83,121.85)
UNNAMED_4_DS90LV001_I18_EN: length 1.8
  TOP w0.15: U52.8 82.57,112.05 82.67,112.15 R245.1
UNNAMED_4_DS90LV001_I38_EN: length 1.8
  TOP w0.15: R249.1 v1(77.14,111.89)
  BOTTOM w0.15: U53.8 77.14,111.15 v1(77.14,111.89)
UNNAMED_4_DS90LV001_I38_OUT: length 3.2
  TOP w0.15: R235.2 75.9,111.81 v1(75.9,111.15)
  BOTTOM w0.15: v1(75.9,111.15) 76.28,110.77 76.28,110.42 76.92,109.78 U53.7
UNNAMED_4_DS90LV001_I38_OUT_1: length 3.2
  TOP w0.15: v1(75.9,107.15) 75.9,106.48 R237.1
  BOTTOM w0.15: v1(75.9,107.15) 76.28,107.53 76.28,107.88 76.92,108.52 U53.6
UNNAMED_4_DS90LV001_I39_EN: length 1.8
  TOP w0.15: U2.8 82.57,133.45 82.67,133.55 R246.1
UNNAMED_4_DS90LV001_I43_EN: length 1.8
  TOP w0.15: R250.1 v1(77.14,133.28)
  BOTTOM w0.15: U54.8 77.14,132.55 v1(77.14,133.28)
UNNAMED_4_DS90LV001_I43_OUT: length 3.2
  TOP w0.15: R242.1 75.9,127.89 v1(75.9,128.55)
  BOTTOM w0.15: U54.6 76.92,129.92 76.28,129.28 76.28,128.93 v1(75.9,128.55)
UNNAMED_4_DS90LV001_I43_OUT_1: length 3.2
  TOP w0.15: R240.2 75.9,133.22 v1(75.9,132.55)
  BOTTOM w0.15: v1(75.9,132.55) 76.28,132.17 76.28,131.82 76.92,131.19 U54.7
UNNAMED_4_DS90LV001_I68_EN: length 1.8
  TOP w0.15: R263.1 82.67,101.45 82.57,101.35 82.57,100.35
UNNAMED_4_DS90LV001_I85_EN: length 1.8
  TOP w0.15: R264.1 82.67,122.85 82.57,122.75 U56.8
UNNAMED_4_DS90LV001_I90_EN: length 1.8
  TOP w0.15: R267.1 v1(77.14,101.19)
  BOTTOM w0.15: v1(77.14,101.19) 77.14,100.45 77.23,100.35
UNNAMED_4_DS90LV001_I90_OUT: length 3.2
  TOP w0.15: R253.2 75.9,101.11 v1(75.9,100.45)
  BOTTOM w0.15: U57.7 76.92,99.09 76.28,99.72 76.28,100.07 v1(75.9,100.45)
UNNAMED_4_DS90LV001_I90_OUT_1: length 3.2
  TOP w0.15: R255.1 75.9,95.78 v1(75.9,96.45)
  BOTTOM w0.15: 77.23,97.81 76.92,97.81 76.28,97.18 76.28,96.83 v1(75.9,96.45)
UNNAMED_4_DS90LV001_I94_EN: length 1.8
  TOP w0.15: R268.1 v1(77.14,122.58)
  BOTTOM w0.15: U58.8 77.14,121.85 v1(77.14,122.58)
UNNAMED_4_DS90LV001_I94_OUT: length 3.2
  TOP w0.15: R256.2 75.9,122.52 v1(75.9,121.85)
  BOTTOM w0.15: v1(75.9,121.85) 76.28,121.47 76.28,121.12 76.92,120.48 U58.7
UNNAMED_4_DS90LV001_I94_OUT_1: length 3.2
  TOP w0.15: v1(75.9,117.85) 75.9,117.19 R258.1
  BOTTOM w0.15: v1(75.9,117.85) 76.28,118.23 76.28,118.58 76.92,119.22 U58.6
UNNAMED_5_CAPACITOR_I14_B: length 6.5
  TOP w0.15: 77.23,46.91 75.73,46.91 R200.1 75.36,46.55 C131.2 73.83,46.42 v1(73.83,45.55) R201.2
  BOTTOM w0.15: R201.2 v1(73.83,45.55)
UNNAMED_5_CAPACITOR_I15_B: length 6.5
  TOP w0.15: R199.1 v1(73.83,49.55) 73.83,48.68 C130.2 75.36,48.55 75.73,48.19 U44.2
  BOTTOM w0.15: R199.1 v1(73.83,49.55)
UNNAMED_5_CAPACITOR_I30_B: length 6.5
  TOP w0.15: U45.3 75.73,68.31 R205.1 75.36,67.95 C133.2 73.83,67.82 v1(73.83,66.95) R206.2
  BOTTOM w0.15: R206.2 v1(73.83,66.95)
UNNAMED_5_CAPACITOR_I31_B: length 6.5
  TOP w0.15: R204.1 v1(73.83,70.95) 73.83,70.08 C132.2 75.36,69.95 75.73,69.59 U45.2
  BOTTOM w0.15: R204.1 v1(73.83,70.95)
UNNAMED_5_CAPACITOR_I61_B: length 6.5
  TOP w0.15: U48.3 75.73,36.22 R218.1 75.36,35.85 C145.2 73.83,35.72 v1(73.83,34.85) R219.2
  BOTTOM w0.15: R219.2 v1(73.83,34.85)
UNNAMED_5_CAPACITOR_I62_B: length 6.5
  TOP w0.15: U48.2 75.73,37.48 R218.2 75.36,37.85 C144.2 73.83,37.98 v1(73.83,38.85) R217.1
  BOTTOM w0.15: R217.1 v1(73.83,38.85)
UNNAMED_5_CAPACITOR_I79_B: length 6.5
  TOP w0.15: U49.3 75.73,57.61 R221.1 75.36,57.25 C147.2 73.83,57.12 v1(73.83,56.25) R222.2
  BOTTOM w0.15: R222.2 v1(73.83,56.25)
UNNAMED_5_CAPACITOR_I80_B: length 6.5
  TOP w0.15: U49.2 75.73,58.89 R221.2 75.36,59.25 C146.2 73.83,59.38 v1(73.83,60.25) R220.1
  BOTTOM w0.15: R220.1 v1(73.83,60.25)
UNNAMED_5_DS90LV001_I18_EN: length 1.8
  TOP w0.15: U44.8 82.57,50.45 82.67,50.55 R209.1
UNNAMED_5_DS90LV001_I38_EN: length 1.8
  TOP w0.15: R213.1 v1(77.14,50.28)
  BOTTOM w0.15: v1(77.14,50.28) 77.14,49.55 U46.8
UNNAMED_5_DS90LV001_I38_OUT: length 3.2
  TOP w0.15: R201.1 75.9,44.88 v1(75.9,45.55)
  BOTTOM w0.15: 77.23,46.91 76.92,46.91 76.28,46.28 76.28,45.93 v1(75.9,45.55)
UNNAMED_5_DS90LV001_I38_OUT_1: length 3.2
  TOP w0.15: v1(75.9,49.55) 75.9,50.22 R199.2
  BOTTOM w0.15: U46.7 76.92,48.19 76.28,48.82 76.28,49.17 v1(75.9,49.55)
UNNAMED_5_DS90LV001_I39_EN: length 1.8
  TOP w0.15: R210.1 82.67,71.95 82.57,71.85 82.57,70.85
UNNAMED_5_DS90LV001_I43_EN: length 1.8
  TOP w0.15: R214.1 v1(77.14,71.69)
  BOTTOM w0.15: 77.23,70.85 77.14,70.95 v1(77.14,71.69)
UNNAMED_5_DS90LV001_I43_OUT: length 3.2
  TOP w0.15: R206.1 75.9,66.28 v1(75.9,66.95)
  BOTTOM w0.15: v1(75.9,66.95) 76.28,67.33 76.28,67.68 76.92,68.31 U47.6
UNNAMED_5_DS90LV001_I43_OUT_1: length 3.2
  TOP w0.15: v1(75.9,70.95) 75.9,71.62 R204.2
  BOTTOM w0.15: v1(75.9,70.95) 76.28,70.57 76.28,70.22 76.92,69.59 U47.7
UNNAMED_5_DS90LV001_I68_EN: length 1.8
  TOP w0.15: R227.1 82.67,39.85 82.57,39.75 U48.8
UNNAMED_5_DS90LV001_I85_EN: length 1.8
  TOP w0.15: U49.8 82.57,61.15 82.67,61.25 R228.1
UNNAMED_5_DS90LV001_I90_EN: length 1.8
  TOP w0.15: R231.1 v1(77.14,39.59)
  BOTTOM w0.15: v1(77.14,39.59) 77.14,38.85 77.23,38.76
UNNAMED_5_DS90LV001_I90_OUT: length 3.2
  TOP w0.15: v1(75.9,34.85) 75.9,34.19 R219.1
  BOTTOM w0.15: 77.23,36.22 76.92,36.22 76.28,35.58 76.28,35.23 v1(75.9,34.85)
UNNAMED_5_DS90LV001_I90_OUT_1: length 3.2
  TOP w0.15: v1(75.9,38.85) 75.9,39.52 R217.2
  BOTTOM w0.15: v1(75.9,38.85) 76.28,38.47 76.28,38.12 76.92,37.48 U50.7
UNNAMED_5_DS90LV001_I94_EN: length 1.8
  TOP w0.15: R232.1 v1(77.14,60.98)
  BOTTOM w0.15: v1(77.14,60.98) 77.14,60.25 U51.8
UNNAMED_5_DS90LV001_I94_OUT: length 3.2
  TOP w0.15: v1(75.9,56.25) 75.9,55.59 R222.1
  BOTTOM w0.15: U51.6 76.92,57.61 76.28,56.98 76.28,56.63 v1(75.9,56.25)
UNNAMED_5_DS90LV001_I94_OUT_1: length 3.2
  TOP w0.15: R220.2 75.9,60.91 v1(75.9,60.25)
  BOTTOM w0.15: U51.7 76.92,58.89 76.28,59.52 76.28,59.87 v1(75.9,60.25)
UNNAMED_10_CAPACITOR_I14_B: length 6.5
  TOP w0.15: R165.2 v1(56.23,40.25) 56.23,41.12 C103.2 57.77,41.25 R164.1 58.13,41.62 U36.3
  BOTTOM w0.15: R165.2 v1(56.23,40.25)
UNNAMED_10_CAPACITOR_I15_B: length 6.5
  TOP w0.15: R163.1 v1(56.23,44.25) 56.23,43.38 C102.2 57.77,43.25 R164.2 58.13,42.88 U36.2
  BOTTOM w0.15: R163.1 v1(56.23,44.25)
UNNAMED_10_CAPACITOR_I30_B: length 6.5
  TOP w0.15: R170.2 v1(56.23,61.65) 56.23,62.52 C105.2 57.77,62.65 R169.1 58.13,63.02 U37.3
  BOTTOM w0.15: R170.2 v1(56.23,61.65)
UNNAMED_10_CAPACITOR_I31_B: length 6.5
  TOP w0.15: U37.2 58.13,64.28 R169.2 57.77,64.65 C104.2 56.23,64.78 v1(56.23,65.65) R168.1
  BOTTOM w0.15: R168.1 v1(56.23,65.65)
UNNAMED_10_CAPACITOR_I61_B: length 6.5
  TOP w0.15: R183.2 v1(56.23,29.55) 56.23,30.42 C117.2 57.77,30.55 R182.1 58.13,30.91 U40.3
  BOTTOM w0.15: R183.2 v1(56.23,29.55)
UNNAMED_10_CAPACITOR_I62_B: length 6.5
  TOP w0.15: R181.1 v1(56.23,33.55) 56.23,32.68 C116.2 57.77,32.55 R182.2 58.13,32.19 U40.2
  BOTTOM w0.15: R181.1 v1(56.23,33.55)
UNNAMED_10_CAPACITOR_I79_B: length 6.5
  TOP w0.15: R186.2 v1(56.23,50.95) 56.23,51.82 C119.2 57.77,51.95 58.13,52.31 U41.3
  BOTTOM w0.15: R186.2 v1(56.23,50.95)
UNNAMED_10_CAPACITOR_I80_B: length 6.5
  TOP w0.15: R184.1 v1(56.23,54.95) 56.23,54.08 C118.2 57.77,53.95 R185.2 58.13,53.59 U41.2
  BOTTOM w0.15: R184.1 v1(56.23,54.95)
UNNAMED_10_DS90LV001_I18_EN: length 1.8
  TOP w0.15: R173.1 65.06,45.25 64.97,45.15 U36.8
UNNAMED_10_DS90LV001_I38_EN: length 1.8
  TOP w0.15: R177.1 v1(59.53,44.98)
  BOTTOM w0.15: v1(59.53,44.98) 59.53,44.25 U38.8
UNNAMED_10_DS90LV001_I38_OUT: length 3.2
  TOP w0.15: v1(58.3,40.25) 58.3,39.59 R165.1
  BOTTOM w0.15: v1(58.3,40.25) 58.68,40.63 58.68,40.98 59.32,41.62 U38.6
UNNAMED_10_DS90LV001_I38_OUT_1: length 3.2
  TOP w0.15: v1(58.3,44.25) 58.3,44.91 R163.2
  BOTTOM w0.15: U38.7 59.32,42.88 58.68,43.52 58.68,43.87 v1(58.3,44.25)
UNNAMED_10_DS90LV001_I39_EN: length 1.8
  TOP w0.15: U37.8 64.97,66.55 65.06,66.65 R174.1
UNNAMED_10_DS90LV001_I43_EN: length 1.8
  TOP w0.15: R178.1 v1(59.53,66.39)
  BOTTOM w0.15: v1(59.53,66.39) 59.53,65.65 U39.8
UNNAMED_10_DS90LV001_I43_OUT: length 3.2
  TOP w0.15: v1(58.3,61.65) 58.3,60.98 R170.1
  BOTTOM w0.15: U39.6 59.32,63.02 58.68,62.38 58.68,62.03 v1(58.3,61.65)
UNNAMED_10_DS90LV001_I43_OUT_1: length 3.2
  TOP w0.15: R168.2 58.3,66.31 v1(58.3,65.65)
  BOTTOM w0.15: U39.7 59.32,64.28 58.68,64.92 58.68,65.27 v1(58.3,65.65)
UNNAMED_10_DS90LV001_I68_EN: length 1.8
  TOP w0.15: R191.1 65.06,34.55 64.97,34.45 U40.8
UNNAMED_10_DS90LV001_I85_EN: length 1.8
  TOP w0.15: R192.1 65.06,55.95 64.97,55.85 U41.8
UNNAMED_10_DS90LV001_I90_EN: length 1.8
  TOP w0.15: R195.1 v1(59.53,34.28)
  BOTTOM w0.15: v1(59.53,34.28) 59.53,33.55 U42.8
UNNAMED_10_DS90LV001_I90_OUT: length 3.2
  TOP w0.15: v1(58.3,29.55) 58.3,28.88 R183.1
  BOTTOM w0.15: U42.6 59.32,30.91 58.68,30.28 58.68,29.93 v1(58.3,29.55)
UNNAMED_10_DS90LV001_I90_OUT_1: length 3.2
  TOP w0.15: R181.2 58.3,34.22 v1(58.3,33.55)
  BOTTOM w0.15: v1(58.3,33.55) 58.68,33.17 58.68,32.82 59.32,32.19 U42.7
UNNAMED_10_DS90LV001_I94_EN: length 1.8
  TOP w0.15: R196.1 v1(59.53,55.69)
  BOTTOM w0.15: U43.8 59.53,54.95 v1(59.53,55.69)
UNNAMED_10_DS90LV001_I94_OUT: length 3.2
  TOP w0.15: v1(58.3,50.95) 58.3,50.28 R186.1
  BOTTOM w0.15: U43.6 59.32,52.31 58.68,51.68 58.68,51.33 v1(58.3,50.95)
UNNAMED_10_DS90LV001_I94_OUT_1: length 3.2
  TOP w0.15: v1(58.3,54.95) 58.3,55.61 R184.2
  BOTTOM w0.15: v1(58.3,54.95) 58.68,54.57 58.68,54.22 59.32,53.59 U43.7

## Text on the board
BOTTOM: J
Package Geometry/Pastemask Bottom: PCXXXXM ISSUE X X FACE ,BOTTOM SOLDER PASTE
User.Comments: PCXXXXM ISSUE X X FACE , BOTTOM SOLDER RESIST | PCXXXXM ISSUE X X FACE , TOP SOLDER RESIST | X     SOLDER RESIST - TOP             MOSTLY RESIST | Y     SOLDER RESIST - BOTTOM          MOSTLY RESIST | A     XX-XX-XX      -----     X.X.XXXXXXX X.X.XXXXXXX  X.X.XXXXXXX | 1:1 | PCB TITLE | PCXXXXM
TOP: A
Package Geometry/Pastemask Top: PCXXXXM ISSUE X X FACE , TOP SOLDER PASTE
POWER: B
INNER TRACKS 1: C
POWER/GND1: D
INNER TRACKS 2: E
INNER TRACKS 3: F
POWER/GND2: G
INNER TRACKS 4: H
GND: I
BODY_CENTER: STFC-RAL | FEB 2011 | M | V     COMPONENT IDENT - TOP | PRE-PROTOTYPE B | XFEL CC
DISPLAY_TOP: W     COMPONENT IDENT - BOTTOM | N
PLACE_BOUND_TOP: LAYER | TRACK | WIDTH | MIN. GAP | Zo | REF:  LAYER/LAYERS | NOTE: ODB++ DATA USED | x                        x&y (STRIPLINE) | x                        x (MICROSTRIP) | @ DIFFERENTIAL IMPEDANCE OF xx OHMS REQUIRED BETWEEN | # DIFFERENTIAL IMPEDANCE OF xx OHMS REQUIRED BETWEEN | BY A yyyum GAP | PAIRS OF xxxum TRACKS RUNNING IN PARALLEL SEPERATED | x                        # SEE BELOW | x                        @ SEE BELOW | TOOL    SYMBOL    SIZE(mm)    PLATED    QTY | T01 | T02 | T03 | T04 | T05 | T06 | T07 | T08 | T09 | T10 | T11 | T12 | T13 | T14 | T15 | T16 | T17 | X     COMPONENT IDENT. - TOP | X     SOLDER RESIST -TOP | A     TOP TRACKS | X     PLANE | X     INNER TRACKS 1 | X     INNER TRACKS 2 | X     INNER TRACKS 3 | X     INNER TRACKS 4 | X     INNER TRACKS 5 | X     INNER TRACKS 6 | X     INNER TRACKS 7 | X     INNER TRACKS 8 | X     BOTTOM TRACKS | X     SOLDER RESIST - BOTTOM | X     COMPONENT IDENT. - BOTTOM | DESCRIPTION | SEE IMPEDANCE TABLE | COMMENT | 6. COPPER FILL MAY BE ADDED TO ASSIST WITH A MORE BALANCED BUILD. | 5. ACCEPTABLE BOARD BOW/TWIST: 0.75% OR LESS ACROSS THE DIAGONAL | CONSULT ENGINEER IF THIS IS NECESSARY. | HOLES +/- 0.05 mm | GENERAL +/- 0.1 mm | SEE NOTES | 1 | HOLE SIZES (FINISHED) | LAYER STRUCTURE | XXX XX Z | PCxxxxM       ISSUE x | DRILLING
DEVICE_TYPE_TOP: AREA FOR HOT | SWAP SWITCH | AND ACTUATOR | RECOMMENDED | RESERVED | OPTIONAL AREA FOR | FACE PLATE MOUNTING | HARDWARE | RESERVED AREA FOR | EXCLUSION AREA - CARD GUIDES
PAGE_OUTLINE: X | 3. MOUNT GROUND BARS AS HIGH OFF OF THE BOARD AS POSSIBLE (LK**). | 2. NOTE - LINKS MARKED WITH LC** AND/OR LO** ARE NOT PHYSICAL COMPONENTS AND NEED NO ASSEMBLY. | SOLDER PASTE MASTERS AVAILABLE FOR ASSEMBLY OF SURFACE MOUNT COMPONENTS. | BOTTOM SOLDER PASTE - PCXXXXM/X X FACE | BOTTOM ASSEMBLY DRG. AVAILABLE - A2-TE-XXXX-XXX-XX-*. | 1. ENSURE CORRECT ORIENTATION OF COMPONENTS AND FIT WITH VALUES | TOP SOLDER PASTE - PCXXXXM/X X FACE | VISIBLE WHERE POSSIBLE. | ASSEMBLY NOTES | BOARD VIEWED ON PRIMARY SIDE - A FACE/COMPONENT SIDE 1 | XXX XX Z | TOP ASSEMBLY
User.8: X | 2. NOTE - LINKS MARKED WITH LC** AND/OR LO** ARE NOT PHYSICAL COMPONENTS AND NEED NO ASSEMBLY. | SOLDER PASTE MASTERS AVAILABLE FOR ASSEMBLY OF SURFACE MOUNT COMPONENTS. | TOP SOLDER PASTE - PCXXXXM/X X FACE | BOTTOM SOLDER PASTE - PCXXXXM/X X FACE | TOP ASSEMBLY DRG. AVAILABLE - A2-TE-XXXX-XXX-XX-*. | 1. ENSURE CORRECT ORIENTATION OF COMPONENTS AND FIT WITH VALUES | VISIBLE WHERE POSSIBLE. | ASSEMBLY NOTES | BOARD VIEWED ON 'Z' FACE | XXX XX Z | BOTTOM ASSEMBLY
User.10: PC3462M/1
User.11: PC3462M/1
User.12: CENTRE LINE | 1A | 0,0
